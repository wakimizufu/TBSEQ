# Repository wakimizufu/TBSEQ (continued)

## KiCad design TBSEQ_Board_V1/controll/controll.kicad_pcb (continued)

Parts:
D1, D2, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33: D; D_DO-15_P10.16mm_Horizontal
S2, S3, S4, S5, S6, S7, S8, S9, S10, S11, S12, S13, S14, S15, S16, S17, S18, S19, S20, S21, S22, S23, S24, S25, S26, S27, S28, S29, S30, S31, S32, S33: B3F-1000S; B3F1060; Manufacturer_Part_Number B3F-1000S; Mouser Part Number 653-B3F-1000-S

Connections:
/SwitchMatrix/SwCol0: D1.1 (K), D10.1 (K), D18.1 (K), D26.1 (K)
/SwitchMatrix/SwCol1: D2.1 (K), D11.1 (K), D19.1 (K), D27.1 (K)
/SwitchMatrix/SwCol2: D4.1 (K), D12.1 (K), D20.1 (K), D28.1 (K)
/SwitchMatrix/SwCol3: D5.1 (K), D13.1 (K), D21.1 (K), D29.1 (K)
/SwitchMatrix/SwCol4: D6.1 (K), D14.1 (K), D22.1 (K), D30.1 (K)
/SwitchMatrix/SwCol5: D7.1 (K), D15.1 (K), D23.1 (K), D31.1 (K)
/SwitchMatrix/SwCol6: D8.1 (K), D16.1 (K), D24.1 (K), D32.1 (K)
/SwitchMatrix/SwCol7: D9.1 (K), D17.1 (K), D25.1 (K), D33.1 (K)
/SwitchMatrix/SwRow0: S2.1 (COM_1), S2.2 (COM_2), S3.1 (COM_1), S3.2 (COM_2), S4.1 (COM_1), S4.2 (COM_2), S5.1 (COM_1), S5.2 (COM_2), S6.1 (COM_1), S6.2 (COM_2), S7.1 (COM_1), S7.2 (COM_2), S8.1 (COM_1), S8.2 (COM_2), S9.1 (COM_1), S9.2 (COM_2)
/SwitchMatrix/SwRow1: S10.1 (COM_1), S10.2 (COM_2), S11.1 (COM_1), S11.2 (COM_2), S12.1 (COM_1), S12.2 (COM_2), S13.1 (COM_1), S13.2 (COM_2), S14.1 (COM_1), S14.2 (COM_2), S15.1 (COM_1), S15.2 (COM_2), S16.1 (COM_1), S16.2 (COM_2), S17.1 (COM_1), S17.2 (COM_2)
/SwitchMatrix/SwRow2: S18.1 (COM_1), S18.2 (COM_2), S19.1 (COM_1), S19.2 (COM_2), S20.1 (COM_1), S20.2 (COM_2), S21.1 (COM_1), S21.2 (COM_2), S22.1 (COM_1), S22.2 (COM_2), S23.1 (COM_1), S23.2 (COM_2), S24.1 (COM_1), S24.2 (COM_2), S25.1 (COM_1), S25.2 (COM_2)
/SwitchMatrix/SwRow3: S26.1 (COM_1), S26.2 (COM_2), S27.1 (COM_1), S27.2 (COM_2), S28.1 (COM_1), S28.2 (COM_2), S29.1 (COM_1), S29.2 (COM_2), S30.1 (COM_1), S30.2 (COM_2), S31.1 (COM_1), S31.2 (COM_2), S32.1 (COM_1), S32.2 (COM_2), S33.1 (COM_1), S33.2 (COM_2)
unnamed: D1.2 (A), S2.3 (N.O._1), S2.4 (N.O._2)
unnamed: D2.2 (A), S3.3 (N.O._1), S3.4 (N.O._2)
unnamed: D4.2 (A), S4.3 (N.O._1), S4.4 (N.O._2)
unnamed: D5.2 (A), S5.3 (N.O._1), S5.4 (N.O._2)
unnamed: D6.2 (A), S6.3 (N.O._1), S6.4 (N.O._2)
unnamed: D7.2 (A), S7.3 (N.O._1), S7.4 (N.O._2)
unnamed: D8.2 (A), S8.3 (N.O._1), S8.4 (N.O._2)
unnamed: D9.2 (A), S9.3 (N.O._1), S9.4 (N.O._2)
unnamed: D10.2 (A), S10.3 (N.O._1), S10.4 (N.O._2)
unnamed: D11.2 (A), S11.3 (N.O._1), S11.4 (N.O._2)
unnamed: D12.2 (A), S12.3 (N.O._1), S12.4 (N.O._2)
unnamed: D13.2 (A), S13.3 (N.O._1), S13.4 (N.O._2)
unnamed: D14.2 (A), S14.3 (N.O._1), S14.4 (N.O._2)
unnamed: D15.2 (A), S15.3 (N.O._1), S15.4 (N.O._2)
unnamed: D16.2 (A), S16.3 (N.O._1), S16.4 (N.O._2)
unnamed: D17.2 (A), S17.3 (N.O._1), S17.4 (N.O._2)
unnamed: D18.2 (A), S18.3 (N.O._1), S18.4 (N.O._2)
unnamed: D19.2 (A), S19.3 (N.O._1), S19.4 (N.O._2)
unnamed: D20.2 (A), S20.3 (N.O._1), S20.4 (N.O._2)
unnamed: D21.2 (A), S21.3 (N.O._1), S21.4 (N.O._2)
unnamed: D22.2 (A), S22.3 (N.O._1), S22.4 (N.O._2)
unnamed: D23.2 (A), S23.3 (N.O._1), S23.4 (N.O._2)
unnamed: D24.2 (A), S24.3 (N.O._1), S24.4 (N.O._2)
unnamed: D25.2 (A), S25.3 (N.O._1), S25.4 (N.O._2)
unnamed: D26.2 (A), S26.3 (N.O._1), S26.4 (N.O._2)
unnamed: D27.2 (A), S27.3 (N.O._1), S27.4 (N.O._2)
unnamed: D28.2 (A), S28.3 (N.O._1), S28.4 (N.O._2)
unnamed: D29.2 (A), S29.3 (N.O._1), S29.4 (N.O._2)
unnamed: D30.2 (A), S30.3 (N.O._1), S30.4 (N.O._2)
unnamed: D31.2 (A), S31.3 (N.O._1), S31.4 (N.O._2)
unnamed: D32.2 (A), S32.3 (N.O._1), S32.4 (N.O._2)
unnamed: D33.2 (A), S33.3 (N.O._1), S33.4 (N.O._2)

Notes on the sheet:
16:NOTE
19:NEXT
26:BANK B
23: PATTERN
12:B
4:D#
7:F#
6:F
15:DOWN
1:C
17:SLIDE
3:D
14:UP
24: PLAY/WRITE
9:G#
21: RUN/STOP
28:BANK D
31:SW31
22: LENMAX
29:SW29
10:A
8:G
27:BANK C
13:C2
11:A#
30:SW30
20:BACK
18:ACC
5:E
25:BANK A
2:C#
32:SW32

Parts:
VR1: RK09D117000B; Manufacturer_Part_Number RK09D117000B; Mouser Part Number 688-RK09D117000B

Connections:
unnamed: VR1.3 (CW), VR1.MH1, VR1.MH2

Notes on the sheet:
ADC Tempo Volume

Parts:
U1, U4: AE-LCNV4-MOSFET; CERDIP-14_W10.16mm_SideBrazed_LongPads_Socket

Connections:
A+SLIDE: U1.2 (HV2)
A-ACC: U1.5 (HV3)
D+3.3V: U1.9 (LV), U4.9 (LV); also elsewhere on the board
D+5V: U1.4 (HV), U4.4 (HV); also elsewhere on the board
D+GATE: U1.12 (LV1); also elsewhere on the board
D+SLIDE: U1.11 (LV2); also elsewhere on the board
D+SyncOut: U1.7 (LV4); also elsewhere on the board
D-ACC: U1.8 (LV3); also elsewhere on the board
GNDD: U1.3 (GND), U1.10 (GND), U4.3 (GND), U4.10 (GND); also elsewhere on the board

Notes on the sheet:
5V-3.3V Convert
2024/7/31 3.3V⇒5V 動作確認済 →場合によっては5V変換後にバッファが必要かも

Parts:
J2: Conn_01x02_Socket; PinHeader_1x02_P2.54mm_Vertical
R7, R8: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
S1: B3F-1000S; B3F1060; Manufacturer_Part_Number B3F-1000S; Mouser Part Number 653-B3F-1000-S
U8: Raspberry Pi Pico DIP-40; Raspberry Pi Pico DIP-40_W17.76mm
U9: IRLML6402(DIP6Convert); DIP-6_W7.62mm

Connections:
A+TEMPO: U8.31 (GP26); also elsewhere on the board
D+3.3V: R7.1, R8.1, U8.36 (3V3(OUT)); also elsewhere on the board
D+3.3V_MIDIRX: U8.16 (GP12); also elsewhere on the board
D+5V: J2.1, U9.2 (Drain); also elsewhere on the board
D+CV_PWM: U8.27 (GP21); also elsewhere on the board
D+GATE: U8.24 (GP18); also elsewhere on the board
D+SLIDE: U8.26 (GP20); also elsewhere on the board
D+SyncIn: U8.21 (GP16); also elsewhere on the board
D+SyncOut: U8.22 (GP17); also elsewhere on the board
D-ACC: U8.25 (GP19); also elsewhere on the board
D_I2C_SCL: R7.2, U8.7 (GP5); also elsewhere on the board
D_I2C_SDA: R8.2, U8.6 (GP4); also elsewhere on the board
GNDD: J2.2, S1.3 (N.O._1), S1.4 (N.O._2), U8.3 (GND), U8.8 (GND), U8.13 (GND), U8.18 (GND), U8.23 (GND), U8.28 (GND), U8.33 (GND), U8.38 (GND); also elsewhere on the board
unnamed: U8.40 (VBUS), U9.4 (Gate)
unnamed: U8.39 (VSYS), U9.6 (Source)
pico_RUN: S1.1 (COM_1), S1.2 (COM_2), U8.30 (RUN)

Notes on the sheet:
ラズパイPico：電池で動作、電池の電圧をOLEDに表示 https://qiita.com/totuto/items/38349e66865d518c45d8
Raspberry Pi Pico Reset Button
USBコネクタ接続時 電流逆流防止
Raspberry Pi Pico

Schematic: FRAM.kicad_sch

Parts:
U3: FM24CL16B(DIP8 Convert); CERDIP-8_W7.62mm_SideBrazed_Socket

Connections:
unnamed: U3.4 (VSS), U3.7 (WP)

Notes on the sheet:
F-RAM 16KByte
Raspberry Pi Pico: I2C Scanner (Arduino IDE) - Finding the Address of I2C Devices https://randomnerdtutorials.com/raspberry-pi-pico-i2c-scanner-arduino/ Scanning... I2C device found at address 0x20 I2C device found at address 0x21 I2C device found at address 0x3C I2C device found at address 0x50 I2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

Schematic: LEDMatrix.kicad_sch

Parts:
D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D66: LED; LED_D3.0mm

Connections:
/LEDMatrix/LedCol0: D41.1 (K), D49.1 (K), D57.1 (K), D66.1 (K)
/LEDMatrix/LedCol1: D34.1 (K), D42.1 (K), D50.1 (K), D58.1 (K)
/LEDMatrix/LedCol2: D35.1 (K), D43.1 (K), D51.1 (K), D59.1 (K)
/LEDMatrix/LedCol3: D36.1 (K), D44.1 (K), D52.1 (K), D60.1 (K)
/LEDMatrix/LedCol4: D37.1 (K), D45.1 (K), D53.1 (K), D61.1 (K)
/LEDMatrix/LedCol5: D38.1 (K), D46.1 (K), D54.1 (K), D62.1 (K)
/LEDMatrix/LedCol6: D39.1 (K), D47.1 (K), D55.1 (K), D63.1 (K)
/LEDMatrix/LedCol7: D40.1 (K), D48.1 (K), D56.1 (K), D64.1 (K)
/LEDMatrix/LedRow0: D34.2 (A), D35.2 (A), D36.2 (A), D37.2 (A), D38.2 (A), D39.2 (A), D40.2 (A), D66.2 (A)
/LEDMatrix/LedRow1: D41.2 (A), D42.2 (A), D43.2 (A), D44.2 (A), D45.2 (A), D46.2 (A), D47.2 (A), D48.2 (A)
/LEDMatrix/LedRow2: D49.2 (A), D50.2 (A), D51.2 (A), D52.2 (A), D53.2 (A), D54.2 (A), D55.2 (A), D56.2 (A)
/LEDMatrix/LedRow3: D57.2 (A), D58.2 (A), D59.2 (A), D60.2 (A), D61.2 (A), D62.2 (A), D63.2 (A), D64.2 (A)

Notes on the sheet:
3:D
23:PATTERN
6:F
30:LED30
5:E
17:SLIDE
27:BANK C
7:F#
29:LED29
21:LEN_MAX
24:PLAY_WRITE
14:UP
12:B
28:BANK D
19:RUN_STOP
9:G#
16:NOTE_ON
18:ACC
8:G
11:A#
1:C
32:LED32
20:NOTE_TIE
22:TRACK
13:C2
10:A
26:BANK B
4:D#
25:BANK A
15:DOWN
31:LED31
2:C#

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
Board: 2 copper layers, 135 parts (0 on the bottom side), 108 nets, no tracks yet.

Other parts of the board:
C11: 0.047uF; C_Rect_L7.0mm_W2.5mm_P5.00mm
D3: 1SS120TD; D_A-405_P2.54mm_Vertical_AnodeUp
J1: KDJ03-5; KDJ035
Q2: 6N138; DIP762W60P254L966H485Q8N
R5, R6: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U6: AE-LCNV4-MOSFET; CERDIP-14_W10.16mm_SideBrazed_LongPads_Socket
U7: FM24CL16B(DIP8 Convert); CERDIP-8_W7.62mm_SideBrazed_Socket
VR2: RK09D117000B

Their connections:
A+SyncIn: U6.1 (HV1); also elsewhere on the board
A+TEMPO: VR2.2 (WIPER); also elsewhere on the board
D+3.3V: U6.9 (LV), U7.8 (VDD), VR2.1 (CCW); also elsewhere on the board
D+3.3V_MIDIRX: U6.11 (LV2); also elsewhere on the board
D+5V: Q2.8 (VCC), R6.1, U6.4 (HV); also elsewhere on the board
D+5V_MIDIRX: Q2.6 (OUTPUT), R6.2, U6.2 (HV2)
D+SyncIn: U6.12 (LV1); also elsewhere on the board
D_I2C_SCL: U7.6 (SCL); also elsewhere on the board
D_I2C_SDA: U7.5 (SDA); also elsewhere on the board
GNDD: C11.2, Q2.5 (GND), U6.3 (GND), U6.10 (GND), U7.4 (VSS), U7.7 (WP), VR2.3 (CW), VR2.MH1, VR2.MH2; also elsewhere on the board
unnamed: D3.2 (A), J1.5, Q2.3 (CATHODE)
unnamed: D3.1 (K), Q2.2 (ANODE), R5.2
unnamed: J1.4, R5.1
unnamed 127: C11.1; also elsewhere on the board

## KiCad design TBSEQ_Board_V1/powersupply/powersupply/powersupply.kicad_pcb

Board: 2 copper layers, 92.0 x 51.0 mm, 27 parts (0 on the bottom side), 9 nets.

Parts:
C1: 1000uF/25V; CP_Radial_D10.0mm_P5.00mm
C2, C3, C5, C8, C9: 0.1uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C4, C10: 100uF/25V; CP_Radial_D5.0mm_P2.50mm
C6: 1uF/25V; CP_Radial_D5.0mm_P2.50mm
C7: 470uF/25V; CP_Radial_D8.0mm_P3.50mm
D1, D4: SBM245L; D_DO-41_SOD81_P7.62mm_Horizontal
D2, D5: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
J1, J4, J5, J6: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J2: DF1BZ-3P-2.5DS; SHDR3W64P0X250_1X3_1000X570X950P
J3: Barrel_Jack_Switch; BarrelJack_Horizontal
J8: DF1BZ-2P-2.5DSA; SHDR2W64P0X250_1X2_750X570X950P
R1: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U3: L7812; TO-220-3_Vertical
U4: LM317_TO-220; TO-220-3_Vertical
U5: L7805; TO-220-3_Vertical
VR1: 3296W-1-502A; 3296W1502A

Connections:
A+5.333V: C6.1, D2.2 (A), D5.1 (K), J2.2, R1.1, U4.2 (VO)
A+12V: C3.1, C4.1, C5.1, D1.2 (A), D2.1 (K), J2.1, U3.3 (OUT), U4.3 (VI)
ADAPTER GND: J3.2, J3.3, J5.2, J6.2
ADAPTER+15V: J3.1, J5.1, J6.1
D+5V: C9.1, C10.1, D4.2 (A), J8.1, U5.3 (OUT)
GNDA: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.2, J2.3, R9.2, U3.2 (GND)
GNDD: C7.2, C8.2, C9.2, C10.2, J4.2, J8.2, U5.2 (GND)
unnamed: C7.1, C8.1, D4.1 (K), J4.1, U5.1 (IN)
unnamed: D5.2 (A), R1.2, U4.1 (ADJ), VR1.2 (WIPER), VR1.3 (CW)

File TBSEQ_Board_V1/powersupply/powersupply/BOM_powersupply.csv:

"Reference","Value","Datasheet","Footprint","Qty","DNP"
"C1","1000uF/25V","~","Capacitor_THT:CP_Radial_D10.0mm_P5.00mm","1",""
"C2,C3,C5","0.1uF","~","Capacitor_THT:C_Disc_D5.1mm_W3.2mm_P5.00mm","3",""
"C4","100uF/25V","~","Capacitor_THT:CP_Radial_D5.0mm_P2.50mm","1",""
"C6","1uF/25V","~","Capacitor_THT:CP_Radial_D5.0mm_P2.50mm","1",""
"C7,C8","10uF","~","Capacitor_THT:C_Disc_D5.1mm_W3.2mm_P5.00mm","2",""
"C9","470uF/25V","~","Capacitor_THT:CP_Radial_D5.0mm_P2.50mm","1",""
"D1","SBM245L","https://www.panjit.com.tw/en/Product/downloadPDF/SBM245L","Diode_THT:D_DO-41_SOD81_P7.62mm_Horizontal","1",""
"D2,D5","1N4001","http://www.vishay.com/docs/88503/1n4001.pdf","Diode_THT:D_DO-41_SOD81_P10.16mm_Horizontal","2",""
"F1","MF-R050","https://www.bourns.com/pdfs/mfr.pdf","SamacSys_Parts:MFR050","1",""
"J1,J4,J5,J6","Conn_01x02_Pin","~","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","4",""
"J2","DF1BZ-3P-2.5DS","https://componentsearchengine.com/Datasheets/1/DF1BZ-3P-2.5DS.pdf","SHDR3W64P0X250_1X3_1000X570X950P","1",""
"J3","Barrel_Jack_Switch","~","Connector_BarrelJack:BarrelJack_Horizontal","1",""
"J8","DF1BZ-2P-2.5DSA","https://componentsearchengine.com/Datasheets/1/DF1BZ-2P-2.5DSA.pdf","SHDR2W64P0X250_1X2_750X570X950P","1",""
"L1","4.7uh/0.5A","~","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal","1",""
"PS1","BP5293-50","https://componentsearchengine.com/Datasheets/1/BP5293-50.pdf","TO254P570X1700X1780-3P","1",""
"R1","120","~","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal","1",""
"R9","330","~","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal","1",""
"U3","L7812","http://www.st.com/content/ccc/resource/technical/document/da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","Package_TO_SOT_THT:TO-220-3_Vertical","1",""
"U4","LM317_TO-220","http://www.ti.com/lit/ds/symlink/lm317.pdf","Package_TO_SOT_THT:TO-220-3_Vertical","1",""
"VR1","3296W-1-502A","https://www.bourns.com/docs/product-datasheets/3296.pdf","SamacSys_Parts:3296W1502A","1",""
