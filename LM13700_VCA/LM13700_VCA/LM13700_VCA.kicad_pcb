# Repository wakimizufu/TBSEQ

## KiCad design LM13700_VCA/LM13700_VCA/LM13700_VCA.kicad_pcb

Parts:
C1, C4: 10uF/25V; CP_Radial_D5.0mm_P2.50mm
C2, C3: 0.01uF; C_Rect_L7.0mm_W2.0mm_P5.00mm
C5, C9, C10, C11, C12: 1uF/25V; CP_Radial_D5.0mm_P2.50mm
C6: 0.1u; C_Disc_D4.7mm_W2.5mm_P5.00mm
C7, C8: 2.2uF/25V; CP_Radial_D5.0mm_P2.50mm
D1, D2, D3, D4: D; D_DO-35_SOD27_P2.54mm_Vertical_AnodeUp
IC1: 2MS1T1B4VS2QES; Manufacturer_Part_Number 2MS1T1B4VS2QES; Mouser Part Number N/A
J1, J3: Conn_01x03; PinSocket_1x03_P2.54mm_Vertical
J2: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
J4: Conn_01x04; PinHeader_1x04_P2.54mm_Horizontal
J5, J11: Conn_01x01; PinSocket_1x01_P2.54mm_Vertical
J6, J7: Conn_01x02; PinHeader_1x02_P2.54mm_Horizontal
J8, J9: MJ-462; MJ462; Manufacturer_Part_Number MJ-462
J10: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
Q1: Q_NPN_ECB; TO-92
R1, R2, R3, R34: 2.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R4: 220K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5, R11, R25, R30, R33, R35: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R6, R12: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R7, R13: 5K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R8: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R9, R10: 510; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R14, R15, R16, R19, R20, R21, R22, R26, R27, R28, R31, R36: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R17, R18: 20K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R23: 30K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R24: 24K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R29, R32: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
U1: LM13700; DIP-16_W7.62mm_Socket
U2: Opamp_Quad; DIP-14_W7.62mm_Socket_LongPads
U3: Opamp_Quad; DIP-14_W7.62mm_Socket
VR1: 3362P-1-102LF 1K; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF
VR2: 3362P-1-104LF 100K; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF
VR3, VR5: 3362P-1-504LF 500K; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF
VR4, VR6: 3362P-1-503LF 50K; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF

Connections:
+5.333VA: J10.1, R3.1, R6.1, R9.1, R10.1, R12.1, R25.1, R35.1, U2.3 (+), U2.5 (+), U2.10 (+), U3.3 (+), U3.5 (+), U3.10 (+), U3.12 (+)
+12VA: J1.3, J3.3, Q1.2 (C), R19.2, R23.2, U1.11 (V+), U2.4 (V+), U3.4 (V+)
A+_VCA_Control: J4.3, R8.1
A+_VCA_Resonance: C3.1, J4.2
A+_VCA_Signal: C2.1, J4.1
COMP_CTRL: R22.1, U1.1
COMP_OUT: C5.1, C12.1, R13.2, U1.8
GNDA: C1.2, C7.2, C8.2, D3.2 (A), D4.1 (K), J1.1, J3.1, J4.4, J6.2, J7.2, J8.S1, J8.SS1, J9.S1, J9.SS1, R7.1, R13.1, R24.1, R30.1, R33.1, U1.6 (V-), U2.11 (V-), U3.11 (V-)
unnamed: C1.1, R1.1, R2.1, R3.2
unnamed: C2.2, R4.1
unnamed: C3.2, R5.1
unnamed: C4.2, R11.1
unnamed: C5.2, R14.1, R17.1
unnamed: C9.2, R25.2, R26.1
unnamed: C10.1, R29.2
unnamed: C11.1, R32.2
unnamed: C12.2, R35.2, R36.1
unnamed: D1.2 (A), R15.2, R16.1
unnamed: D1.1 (K), D2.2 (A), U2.1
unnamed: D2.1 (K), R14.2, R15.1, U2.2 (-)
unnamed: D3.1 (K), D4.2 (A), IC1.1
unnamed: IC1.2 (2_Comm), R31.1, R34.2
unnamed: J1.2, J2.1
unnamed: C11.2, J6.1, J8.T1, J8.TS1, R33.2
unnamed: C10.2, J7.1, J9.T1, J9.TS1, R30.2
unnamed: J3.2, J10.2
unnamed: J5.1, J11.1, U2.13 (-), U2.14
unnamed: Q1.3 (B), U2.8, VR3.1 (CCW), VR3.2 (WIPER)
unnamed: Q1.1 (E), R22.2
unnamed: R6.2, U1.10, U1.12
unnamed: R8.2, U1.16
unnamed: R12.2, U1.5, U1.7
unnamed: R27.2, R28.1, U3.1
unnamed: R2.2, R4.2, R5.2, U1.14 (+)
unnamed: R1.2, U1.13 (-)
unnamed: R10.2, R11.2, U1.3 (+)
unnamed: R9.2, U1.4 (-)
unnamed: C6.2, R16.2, R17.2, R18.1, U2.6 (-)
unnamed: R20.1, R21.2, U2.9 (-)
unnamed: C8.1, R23.1, R24.2, U2.12 (+)
unnamed: R26.2, R27.1, U3.2 (-)
unnamed: R28.2, U3.6 (-), VR4.3 (CW)
unnamed: R36.2, U3.9 (-), VR6.3 (CW)
unnamed: R31.2, U3.13 (-), VR5.3 (CW)
unnamed: C7.1, R20.2, VR1.1 (CCW), VR1.2 (WIPER), VR2.3 (CW)
unnamed: C6.1, R18.2, U2.7, VR1.3 (CW)
unnamed: R19.1, VR2.1 (CCW), VR2.2 (WIPER)
unnamed: R21.1, VR3.3 (CW)
unnamed: R29.1, U3.7, VR4.1 (CCW), VR4.2 (WIPER)
unnamed: R32.1, U3.14, VR5.1 (CCW), VR5.2 (WIPER)
unnamed: R34.1, U3.8, VR6.1 (CCW), VR6.2 (WIPER)
VCA_OUT: C4.1, C9.1, R7.2, U1.9

Notes on the sheet:
Ratio
Release
5.333V
COMP OUT
Gain
Output
COMP CNTL
Attack
COMP AMP/DISTORTION
TB VCA
VCA OUT

Board: 2 copper layers, 100.0 x 84.0 mm, 74 parts (0 on the bottom side), 52 nets.

File LM13700_VCA/LM13700_VCA/BOM_LM13700_VCA.tsv:

Reference	Value	Datasheet	Footprint	Qty	DNP
C1,C4	10uF/25V	~	Capacitor_THT:CP_Radial_D5.0mm_P2.50mm	2	
C2,C3	0.01uF	~	Capacitor_THT:C_Rect_L7.0mm_W2.0mm_P5.00mm	2	
C5,C9,C10,C11,C12	1uF/25V	~	Capacitor_THT:CP_Radial_D5.0mm_P2.50mm	5	
C6	0.1u	~	Capacitor_THT:C_Disc_D4.7mm_W2.5mm_P5.00mm	1	
C7,C8	2.2uF/25V	~	Capacitor_THT:CP_Radial_D5.0mm_P2.50mm	2	
D1,D2,D3,D4	D	~	Diode_THT:D_DO-35_SOD27_P2.54mm_Vertical_AnodeUp	4	
IC1	2MS1T1B4VS2QES	https://akizukidenshi.com/download/ds/cosland/2MS1-T1-B4-VS2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	2MS1T1B4VS2QES	1	
J1,J3	Conn_01x03	~	Connector_PinSocket_2.54mm:PinSocket_1x03_P2.54mm_Vertical	2	
J2,J5	Conn_01x01	~	-- ミックスされた値 --	2	
J4	Conn_01x04	~	Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Horizontal	1	
J6,J7	Conn_01x02	~	Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Horizontal	2	
J8,J9	MJ-462	https://akizukidenshi.com/download/ds/avvicon/MJ-462.pdf	SamacSys_Parts:MJ462	2	
Q1	Q_NPN_ECB	~	Package_TO_SOT_THT:TO-92	1	
R1,R2,R3,R34	2.2K	~	Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical	4	
R4	220K	~	Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical	1	
R5,R11,R25,R30,R33,R35	100K	~	Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical	6	
R6,R12	33K	~	Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical	2	
R7,R13	5K	~	Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical	2	
R8	47K	~	Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical	1	
R9,R10	510	~	Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical	2	
R14,R15,R16,R19,R20,R21,R22,R26,R27,R28,R31,R36	10K	~	Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical	12	
R17,R18	20K	~	Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical	2	
R23	30K	~	Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical	1	
R24	24K	~	Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical	1	
R29,R32	100	~	Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical	2	
U1	LM13700	http://www.ti.com/lit/ds/symlink/lm13700.pdf	Package_DIP:DIP-16_W7.62mm_Socket	1	
U2,U3	Opamp_Quad	~	-- ミックスされた値 --	2	
VR1	3362P-1-102LF 1K	https://datasheet.datasheetarchive.com/originals/distributor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	SamacSys_Parts:3362P_1	1	
VR2	3362P-1-104LF 100K	https://datasheet.datasheetarchive.com/originals/distributor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	SamacSys_Parts:3362P_1	1	
VR3,VR5	3362P-1-504LF 500K	https://datasheet.datasheetarchive.com/originals/distributor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	SamacSys_Parts:3362P_1	2	
VR4,VR6	3362P-1-503LF 50K	https://datasheet.datasheetarchive.com/originals/distributor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	SamacSys_Parts:3362P_1	2

## KiCad design TBSEQ_Board_V1/HT16K33Panel/HT16K33Panel/HT16K33Panel.kicad_pcb

Parts:
C1: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3: 1N4148W; D_SOD-123
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13: 39k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U7: HT16K33_28SOP-A_; SOIC127P1031X264-28N; Manufacturer_Part_Number HT16K33(28SOP-A)

Connections:
COM0: U7.2 (COM0/AD); also elsewhere on the board
COM1: D1.2 (A), U7.3 (COM1/KS0); also elsewhere on the board
COM1/KS0: D1.1 (K); also elsewhere on the board
COM2/KS1: D2.1 (K); also elsewhere on the board
COM3/KS2: D3.1 (K); also elsewhere on the board
D+3.3V: C1.1, U7.28 (VDD); also elsewhere on the board
D_I2C_SCL: U7.26 (SCL); also elsewhere on the board
D_I2C_SDA: U7.27 (SDA); also elsewhere on the board
GNDD: C1.2, U7.1 (VSS); also elsewhere on the board
unnamed: D2.2 (A), U7.4 (COM2/KS1)
unnamed: D3.2 (A), U7.5 (COM3/KS2)
Row0: U7.25 (ROW0/A2); also elsewhere on the board
Row1: U7.24 (ROW1/A1); also elsewhere on the board
Row2: U7.23 (ROW2/A0); also elsewhere on the board
Row3: R1.1, U7.22 (ROW3/K1); also elsewhere on the board
Row4: R2.1, U7.21 (ROW4/K2); also elsewhere on the board
Row5: R3.1, U7.20 (ROW5/K3); also elsewhere on the board
Row6: R4.1, U7.19 (ROW6/K4); also elsewhere on the board
Row7: R5.1, U7.18 (ROW7/K5); also elsewhere on the board
Row8: R6.1, U7.17 (ROW8/K6); also elsewhere on the board
Row9: R7.1, U7.16 (ROW9/K7); also elsewhere on the board
Row10: R8.1, U7.15 (ROW10/K8); also elsewhere on the board
Row11: R9.1, U7.14 (ROW11/K9); also elsewhere on the board
Row12: R10.1, U7.13 (ROW12/K10); also elsewhere on the board
Row13: R11.1, U7.12 (ROW13/K11); also elsewhere on the board
Row14: R12.1, U7.11 (ROW14/K12); also elsewhere on the board
Row15: R13.1, U7.10 (ROW15/K13/INT); also elsewhere on the board
RowK3: R1.2; also elsewhere on the board
RowK4: R2.2; also elsewhere on the board
RowK5: R3.2; also elsewhere on the board
RowK6: R4.2; also elsewhere on the board
RowK7: R5.2; also elsewhere on the board
RowK8: R6.2; also elsewhere on the board
RowK9: R7.2; also elsewhere on the board
RowK10: R8.2; also elsewhere on the board
RowK11: R9.2; also elsewhere on the board
RowK12: R10.2; also elsewhere on the board
RowK13: R11.2; also elsewhere on the board
RowK14: R12.2; also elsewhere on the board
RowK15: R13.2; also elsewhere on the board

Parts:
D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35: LED; LED_D3.0mm

Connections:
COM0: D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K); also elsewhere on the board
COM1: D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K); also elsewhere on the board
Row0: D4.2 (A), D20.2 (A); also elsewhere on the board
Row1: D5.2 (A), D21.2 (A); also elsewhere on the board
Row2: D6.2 (A), D22.2 (A); also elsewhere on the board
Row3: D7.2 (A), D23.2 (A); also elsewhere on the board
Row4: D8.2 (A), D24.2 (A); also elsewhere on the board
Row5: D9.2 (A), D25.2 (A); also elsewhere on the board
Row6: D10.2 (A), D26.2 (A); also elsewhere on the board
Row7: D11.2 (A), D27.2 (A); also elsewhere on the board
Row8: D12.2 (A), D28.2 (A); also elsewhere on the board
Row9: D13.2 (A), D29.2 (A); also elsewhere on the board
Row10: D14.2 (A), D30.2 (A); also elsewhere on the board
Row11: D15.2 (A), D31.2 (A); also elsewhere on the board
Row12: D16.2 (A), D32.2 (A); also elsewhere on the board
Row13: D17.2 (A), D33.2 (A); also elsewhere on the board
Row14: D18.2 (A), D34.2 (A); also elsewhere on the board
Row15: D19.2 (A), D35.2 (A); also elsewhere on the board

Notes on the sheet:
14:UP
18:SLIDE
31:LED31
3:D
28:BANK D
13:C2
32:LED32
21:RUN_STOP
25:BANK A
6:F
15:DOWN
30:LED30
22:TRACK
11:A#
5:E
19:ACC
17:NOTE_TIE
20:LEN_MAX
10:A
29:LED29
12:B
8:G
4:D#
26:BANK B
9:G#
2:C#
1:C
7:F#
27:BANK C
16:NOTE_ON
24:PLAY_WRITE
23:PATTERN

Parts:
J4, J5, J8, J9: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J6, J7, J10, J11: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical
R14, R15: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
S35: B3F-1000S; B3F1060; Manufacturer_Part_Number B3F-1000S; Mouser Part Number 653-B3F-1000-S
U1: Raspberry Pi Pico DIP-40; Raspberry Pi Pico DIP-40_W17.76mm
U2: IRLML6402(DIP6Convert); DIP-6_W7.62mm

Connections:
A+TEMPO: U1.31 (GP26); also elsewhere on the board
D+3.3V: J11.1, R14.1, R15.1, U1.36 (3V3(OUT)); also elsewhere on the board
D+5V: U2.2 (Drain); also elsewhere on the board
D+CV_PWM: U1.27 (GP21); also elsewhere on the board
D+GATE: U1.24 (GP18); also elsewhere on the board
D+SLIDE: U1.26 (GP20); also elsewhere on the board
D+SyncOut: U1.22 (GP17); also elsewhere on the board
D+VBUS: U1.39 (VSYS), U2.6 (Source)
D+VSYS: U1.40 (VBUS), U2.4 (Gate)
D-ACC: U1.25 (GP19); also elsewhere on the board
D_I2C_SCL: J11.3, R15.2, U1.7 (GP5); also elsewhere on the board
D_I2C_SDA: J11.2, R14.2, U1.6 (GP4); also elsewhere on the board
GNDD: J11.4, S35.3 (N.O._1), S35.4 (N.O._2), U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (GND), U1.38 (GND); also elsewhere on the board
unnamed: J4.1, U1.1 (GP0)
unnamed: J4.2, U1.2 (GP1)
unnamed: J5.1, U1.4 (GP2)
unnamed: J5.2, U1.5 (GP3)
unnamed: J6.1, U1.9 (GP6)
unnamed: J6.2, U1.10 (GP7)
unnamed: J6.3, U1.11 (GP8)
unnamed: J6.4, U1.12 (GP9)
unnamed: J7.1, U1.14 (GP10)
unnamed: J7.2, U1.15 (GP11)
unnamed: J7.3, U1.16 (GP12)
unnamed: J7.4, U1.17 (GP13)
unnamed: J8.1, U1.19 (GP14)
unnamed: J8.2, U1.20 (GP15)
unnamed: J9.1, U1.29 (GP22)
unnamed: J9.2, U1.21 (GP16)
unnamed: J10.1, U1.37 (3V3_EN)
unnamed: J10.2, U1.35 (ADC_VREF)
unnamed: J10.3, U1.34 (GP28)
unnamed: J10.4, U1.32 (GP27)
unnamed: S35.1 (COM_1), S35.2 (COM_2), U1.30 (RUN)

Notes on the sheet:
Raspberry Pi Pico
ラズパイPico：電池で動作、電池の電圧をOLEDに表示 https://qiita.com/totuto/items/38349e66865d518c45d8
Raspberry Pi Pico Reset Button
USBコネクタ接続時 電流逆流防止

Parts:
VR1: RK09D117000B; Manufacturer_Part_Number RK09D117000B; Mouser Part Number 688-RK09D117000B

Connections:
A+TEMPO: VR1.2 (WIPER); also elsewhere on the board
D+3.3V: VR1.1 (CCW); also elsewhere on the board
GNDD: VR1.3 (CW), VR1.MH1, VR1.MH2; also elsewhere on the board

Notes on the sheet:
ADC Tempo Volume

Parts:
J3, J14: Conn_01x04_Pin; PinSocket_1x04_P2.54mm_Vertical
U4: AE-LCNV4-MOSFET; CERDIP-14_W10.16mm_SideBrazed_LongPads_Socket
U5: 74HC126; DIP-14_W7.62mm

Connections:
A+GATE: U5.3; also elsewhere on the board
A+SLIDE: U5.6; also elsewhere on the board
A+SyncOut: U5.11; also elsewhere on the board
A-ACC: U5.8; also elsewhere on the board
D+3.3V: U4.9 (LV); also elsewhere on the board
D+5V: U4.4 (HV), U5.1, U5.4, U5.10, U5.13, U5.14 (VCC); also elsewhere on the board
D+GATE: U5.2; also elsewhere on the board
D+SLIDE: U5.5; also elsewhere on the board
D+SyncOut: U5.12; also elsewhere on the board
D-ACC: U5.9; also elsewhere on the board
GNDD: U4.3 (GND), U4.10 (GND), U5.7 (GND); also elsewhere on the board
unnamed: J3.1, U4.1 (HV1)
unnamed: J3.2, U4.2 (HV2)
unnamed: J3.3, U4.5 (HV3)
unnamed: J3.4, U4.6 (HV4)
unnamed: J14.1, U4.12 (LV1)
unnamed: J14.2, U4.11 (LV2)
unnamed: J14.3, U4.8 (LV3)
unnamed: J14.4, U4.7 (LV4)

Notes on the sheet:
3.3V=>5V OutputBuffer
2024/8/5 動作確認済
5V=>3.3V Convert

Parts:
J2: Conn_01x02_Socket; PinHeader_1x02_P2.54mm_Vertical
J16: Conn_01x03_Pin; PinSocket_1x03_P2.54mm_Vertical

Connections:
D+3.3V: J16.2; also elsewhere on the board
D+5V: J2.1, J16.1; also elsewhere on the board
GNDD: J2.2, J16.3; also elsewhere on the board

Parts:
D37, D38, D39: LED; LED_D3.0mm
J12: Conn_01x08_Pin; PinHeader_1x08_P2.54mm_Vertical
J13: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J17: Conn_01x03_Socket; PinSocket_1x03_P2.54mm_Vertical
R21, R22, R23: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical

Connections:
A+CV: J12.5; also elsewhere on the board
A+GATE: J12.1; also elsewhere on the board
A+SLIDE: J12.2; also elsewhere on the board
A+SyncOut: J12.4; also elsewhere on the board
A-ACC: J12.3; also elsewhere on the board
GNDD: D37.1 (K), D38.1 (K), D39.1 (K), J12.8; also elsewhere on the board
unnamed: D37.2 (A), R21.2
unnamed: D38.2 (A), R22.2
unnamed: D39.2 (A), R23.2
unnamed: J12.6, J13.1
unnamed: J12.7, J13.2
unnamed: J17.1, R21.1
unnamed: J17.2, R22.1
unnamed: J17.3, R23.1
