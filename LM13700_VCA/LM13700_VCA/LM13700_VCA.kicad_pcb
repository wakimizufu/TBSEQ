# Repository wakimizufu/TBSEQ (continued)

## KiCad design TBSEQ_Board_V1/HT16K33Panel/HT16K33Panel/HT16K33Panel.kicad_pcb (continued)

Parts:
S1, S2, S3, S4, S5, S6, S7, S8, S9, S10, S11, S12, S13, S14, S15, S16, S17, S18, S19, S20, S21, S22, S23, S24, S25, S26, S27, S28, S29, S30, S31, S32, S33, S34: B3F-1000S; B3F1060; Manufacturer_Part_Number B3F-1000S; Mouser Part Number 653-B3F-1000-S

Connections:
COM1/KS0: S1.1 (COM_1), S1.2 (COM_2), S2.1 (COM_1), S2.2 (COM_2), S3.1 (COM_1), S3.2 (COM_2), S4.1 (COM_1), S4.2 (COM_2), S5.1 (COM_1), S5.2 (COM_2), S6.1 (COM_1), S6.2 (COM_2), S7.1 (COM_1), S7.2 (COM_2), S8.1 (COM_1), S8.2 (COM_2), S9.1 (COM_1), S9.2 (COM_2), S10.1 (COM_1), S10.2 (COM_2), S11.1 (COM_1), S11.2 (COM_2), S12.1 (COM_1), S12.2 (COM_2), S13.1 (COM_1), S13.2 (COM_2); also elsewhere on the board
COM2/KS1: S14.1 (COM_1), S14.2 (COM_2), S15.1 (COM_1), S15.2 (COM_2), S16.1 (COM_1), S16.2 (COM_2), S17.1 (COM_1), S17.2 (COM_2), S18.1 (COM_1), S18.2 (COM_2), S19.1 (COM_1), S19.2 (COM_2), S20.1 (COM_1), S20.2 (COM_2), S21.1 (COM_1), S21.2 (COM_2), S22.1 (COM_1), S22.2 (COM_2), S23.1 (COM_1), S23.2 (COM_2), S24.1 (COM_1), S24.2 (COM_2), S25.1 (COM_1), S25.2 (COM_2), S26.1 (COM_1), S26.2 (COM_2); also elsewhere on the board
COM3/KS2: S27.1 (COM_1), S27.2 (COM_2), S28.1 (COM_1), S28.2 (COM_2), S29.1 (COM_1), S29.2 (COM_2), S30.1 (COM_1), S30.2 (COM_2), S31.1 (COM_1), S31.2 (COM_2), S32.1 (COM_1), S32.2 (COM_2), S33.1 (COM_1), S33.2 (COM_2), S34.1 (COM_1), S34.2 (COM_2); also elsewhere on the board
RowK3: S1.3 (N.O._1), S1.4 (N.O._2), S14.3 (N.O._1), S14.4 (N.O._2), S27.3 (N.O._1), S27.4 (N.O._2); also elsewhere on the board
RowK4: S2.3 (N.O._1), S2.4 (N.O._2), S15.3 (N.O._1), S15.4 (N.O._2), S28.3 (N.O._1), S28.4 (N.O._2); also elsewhere on the board
RowK5: S3.3 (N.O._1), S3.4 (N.O._2), S16.3 (N.O._1), S16.4 (N.O._2), S29.3 (N.O._1), S29.4 (N.O._2); also elsewhere on the board
RowK6: S4.3 (N.O._1), S4.4 (N.O._2), S17.3 (N.O._1), S17.4 (N.O._2), S30.3 (N.O._1), S30.4 (N.O._2); also elsewhere on the board
RowK7: S5.3 (N.O._1), S5.4 (N.O._2), S18.3 (N.O._1), S18.4 (N.O._2), S31.3 (N.O._1), S31.4 (N.O._2); also elsewhere on the board
RowK8: S6.3 (N.O._1), S6.4 (N.O._2), S19.3 (N.O._1), S19.4 (N.O._2), S32.3 (N.O._1), S32.4 (N.O._2); also elsewhere on the board
RowK9: S7.3 (N.O._1), S7.4 (N.O._2), S20.3 (N.O._1), S20.4 (N.O._2), S33.3 (N.O._1), S33.4 (N.O._2); also elsewhere on the board
RowK10: S8.3 (N.O._1), S8.4 (N.O._2), S21.3 (N.O._1), S21.4 (N.O._2), S34.3 (N.O._1), S34.4 (N.O._2); also elsewhere on the board
RowK11: S9.3 (N.O._1), S9.4 (N.O._2), S22.3 (N.O._1), S22.4 (N.O._2); also elsewhere on the board
RowK12: S10.3 (N.O._1), S10.4 (N.O._2), S23.3 (N.O._1), S23.4 (N.O._2); also elsewhere on the board
RowK13: S11.3 (N.O._1), S11.4 (N.O._2), S24.3 (N.O._1), S24.4 (N.O._2); also elsewhere on the board
RowK14: S12.3 (N.O._1), S12.4 (N.O._2), S25.3 (N.O._1), S25.4 (N.O._2); also elsewhere on the board
RowK15: S13.3 (N.O._1), S13.4 (N.O._2), S26.3 (N.O._1), S26.4 (N.O._2); also elsewhere on the board

Notes on the sheet:
4:D#
13:C2
11:A#
1:C
19:NEXT
10:A
27:BANK A
5:E
14:UP
2:C#
18:ACC
24: TRACK
16:NOTE
3:D
7:F#
31:SW31
8:G
6:F
32:SW32
21: LENMAX
26: PLAY/WRITE
17:SLIDE
23: FUNCTION
34:SW34
9:G#
25: PATTERN
29:BANK C
12:B
22: RUN/STOP
20:BACK
33:SW33
15:DOWN
30:BANK D
28:BANK B

Schematic: MIDI_RX.kicad_sch

Parts:
C3: 0.1uF; C_Rect_L7.0mm_W2.0mm_P5.00mm
D36: 1SS120TD; D_A-405_P2.54mm_Vertical_AnodeUp
J1: KDJ03-5; KDJ035; Manufacturer_Part_Number KDJ03-5
J15: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
R19, R20: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U8: TLP2304_TPR,E; SOIC127P700X230-6N; Manufacturer_Part_Number TLP2304(TPR,E; Mouser Part Number 757-TLP2304TPRE

Connections:
GNDD: C3.2, J1.MH1, J1.MH2, J15.3, U8.4 (GND); also elsewhere on the board
unnamed: D36.2 (A), J1.5, U8.3 (CATHODE)
unnamed: D36.1 (K), R19.2, U8.1 (ANODE)
unnamed: J1.4, R19.1
unnamed: C3.1, J15.1, R20.1, U8.6 (VCC)
unnamed: J15.2, R20.2, U8.5 (VO_(OUTPUT))

Notes on the sheet:
MIDI Interface(RX only)
MIDI送受信回路で使うオプトアイソレータはどれが良い？ https://b.meso.tokyo/post/722104583178092544/opt-isolator-selection-guide-for-midi ⇒TLP2361,TLP2304

Schematic: FRAM.kicad_sch

Parts:
U3: FM24CL16B(DIP8 Convert); CERDIP-8_W7.62mm_SideBrazed_Socket

Connections:
D+3.3V: U3.8 (VDD); also elsewhere on the board
D_I2C_SCL: U3.6 (SCL); also elsewhere on the board
D_I2C_SDA: U3.5 (SDA); also elsewhere on the board
GNDD: U3.4 (VSS), U3.7 (WP); also elsewhere on the board

Notes on the sheet:
F-RAM 16KByte
Raspberry Pi Pico: I2C Scanner (Arduino IDE) - Finding the Address of I2C Devices https://randomnerdtutorials.com/raspberry-pi-pico-i2c-scanner-arduino/ Scanning... I2C device found at address 0x20 I2C device found at address 0x21 I2C device found at address 0x3C I2C device found at address 0x50 I2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

Schematic: CV.kicad_sch

Parts:
C2: 0.047uF; C_Rect_L7.0mm_W2.5mm_P5.00mm
R16: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R17: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R18: 5.1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U6: LM358; DIP-8_W7.62mm

Connections:
A+CV: R18.2, U6.7; also elsewhere on the board
D+5V: U6.8 (V+); also elsewhere on the board
D+CV_PWM: R16.1; also elsewhere on the board
GNDD: C2.2, R17.2, U6.4 (V-); also elsewhere on the board
unnamed: C2.1, R16.2, U6.3 (+)
unnamed: U6.1, U6.2 (-), U6.5 (+)
unnamed: R17.1, R18.1, U6.6 (-)

Notes on the sheet:
CV PMW to DAC Convert

Board: 2 copper layers, 150.0 x 140.0 mm, 126 parts (0 on the bottom side), 99 nets.

File TBSEQ_Board_V1/HT16K33Panel/HT16K33Panel/BOM_HT16K33Panel.csv:

"Reference","Value","Datasheet","Footprint","Qty","DNP"
"C1,C3","0.1uF","~","-- ミックスされた値 --","2",""
"C2","0.047uF","~","Capacitor_THT:C_Rect_L7.0mm_W2.5mm_P5.00mm","1",""
"D1,D2,D3","1N4148W","https://www.vishay.com/docs/85748/1n4148w.pdf","Diode_SMD:D_SOD-123","3",""
"D4,D5,D6,D7,D8,D9,D10,D11,D12,D13,D14,D15,D16,D17,D18,D19,D20,D21,D22,D23,D24,D25,D26,D27,D28,D29,D30,D31,D32,D33,D34,D35,D37,D38,D39","LED","~","LED_THT:LED_D3.0mm","35",""
"D36","1SS120TD","~","Diode_THT:D_A-405_P2.54mm_Vertical_AnodeUp","1",""
"J1","KDJ03-5","https://akizukidenshi.com/download/ds/useconn/KDJ03-5.pdf","SamacSys_Parts:KDJ035","1",""
"J2","Conn_01x02_Socket","~","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1",""
"J3,J14","Conn_01x04_Pin","~","Connector_PinSocket_2.54mm:PinSocket_1x04_P2.54mm_Vertical","2",""
"J4,J5,J8,J9,J13","Conn_01x02_Pin","~","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","5",""
"J6,J7,J10,J11","Conn_01x04_Socket","~","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical","4",""
"J12","Conn_01x08_Pin","~","Connector_PinHeader_2.54mm:PinHeader_1x08_P2.54mm_Vertical","1",""
"J15,J16","Conn_01x03_Pin","~","-- ミックスされた値 --","2",""
"J17","Conn_01x03_Socket","~","Connector_PinSocket_2.54mm:PinSocket_1x03_P2.54mm_Vertical","1",""
"R1,R2,R3,R4,R5,R6,R7,R8,R9,R10,R11,R12,R13","39k","~","Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder","13",""
"R14,R15,R21,R22,R23","1K","~","-- ミックスされた値 --","5",""
"R16","22K","~","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal","1",""
"R17","10K","~","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal","1",""
"R18","5.1K","~","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal","1",""
"R19,R20","220","~","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal","2",""
"S1,S2,S3,S4,S5,S6,S7,S8,S9,S10,S11,S12,S13,S14,S15,S16,S17,S18,S19,S20,S21,S22,S23,S24,S25,S26,S27,S28,S29,S30,S31,S32,S33,S34,S35","B3F-1000S","https://www.mouser.com/datasheet/2/307/en-b3f-13826.pdf","SamacSys_Parts:B3F1060","35",""
"U1","Raspberry Pi Pico DIP-40","","SamacSys_Parts:Raspberry Pi Pico DIP-40_W17.76mm","1",""
"U2","IRLML6402(DIP6Convert)","","Package_DIP:DIP-6_W7.62mm","1",""
"U3","FM24CL16B(DIP8 Convert)","https://www.infineon.com/dgdl/Infineon-FM24CL16B_16-Kbit_(2_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","Package_DIP:CERDIP-8_W7.62mm_SideBrazed_Socket","1",""
"U4","AE-LCNV4-MOSFET","https://akizukidenshi.com/goodsaffix/AE-LCNV4-MOSFET_20200316.pdf","SamacSys_Parts:CERDIP-14_W10.16mm_SideBrazed_LongPads_Socket","1",""
"U5","74HC126","http://www.ti.com/lit/gpn/sn74LS126","Package_DIP:DIP-14_W7.62mm","1",""
"U6","LM358","http://www.ti.com/lit/ds/symlink/lm2904-n.pdf","Package_DIP:DIP-8_W7.62mm","1",""
"U7","HT16K33_28SOP-A_","https://cdn-shop.adafruit.com/datasheets/ht16K33v110.pdf","SOIC127P1031X264-28N","1",""
"U8","TLP2304_TPR,E","http://toshiba.semicon-storage.com/info/docget.jsp?did=63378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","SamacSys_Parts:SOIC127P700X230-6N","1",""
"VR1","RK09D117000B","https://tech.alpsalpine.com/prod/j/html/potentiometer/rotary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","SamacSys_Parts:RK09D117000B","1",""

## KiCad design TBSEQ_Board_V1/analog_separate/analog_separate.kicad_pcb

Board: 2 copper layers, 200.0 x 100.0 mm, 185 parts (0 on the bottom side), 125 nets.

Parts:
C10, C20, C21, C33: 0.01uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C11, C13, C14, C15, C17, C22, C23, C29, C42, C62: 1uF/50V; CP_Radial_D5.0mm_P2.00mm
C16, C30, C37, C72: 10uF/16V; CP_Radial_D4.0mm_P2.00mm
C18: 0.018uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C19, C24, C26, C36: 0.033uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C25, C27, C41: 0.1uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C28, C55: 47uF/16V; CP_Radial_D4.0mm_P2.00mm
C34: 0.001uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C35: 0.22uF; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C54: 0.047uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
D24, D25, D26, D27, D28, D29, D31, D32, D35, D36, D37: D; D_A-405_P2.54mm_Vertical_AnodeUp
IC11, IC11_1: AN6562; DIP-8_W7.62mm
IC12: 4066; DIP-14_W7.62mm
IC15: CA3080A; DIP-8_W7.62mm
J1, J5, J7: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J2: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
J3, J4, J8: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J9, J13: Conn_01x01_Pin; PinHeader_1x01_P2.54mm_Vertical
Q8, Q9, Q10, Q27, Q31, Q36, Q38: PNP; TO-92_Inline
Q11, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q23, Q24, Q25, Q29, Q30, Q32, Q35, Q37, Q40, Q41: NPN; TO-92_Inline
Q12, Q21, Q22, Q26: HN1C01FU-GR,LF_6P DIP; DIP-6_W7.62mm
Q28, Q39: NJFET; TO-92_Inline
R34, R36, R47, R61, R64, R65, R94, R96, R97, R101, R105, R109, R112, R115, R116, R142, R143, R144, R145, R148, R149: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R35, R59, R66, R72, R73, R92, R93, R99, R102, R113, R114, R118, R122, R139, R140, R141: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R45, R110, R111, R117, R120, R134, R146, R151: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R46, R119: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R62, R63, R103, R121, R131: 220K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R67, R68, R69, R70, R71, R98, R104, R107, R108, R124, R125, R126, R133: 2.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R91: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R95, R130, R132, R152: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R100, R100_1: 1K(TEMPCO); R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R106: 27K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R123: 1.5M; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R138: 68K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R147, R150: 22; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
SW1: 2MS1T1B4VS2QES
TM3: 500K; 3296W1502A
TM4: 50K; 3296W1502A
TM5: 5K; 3296W1502A
VCA_C_1, VCA_C_2: 10uF/16V; CP_Radial_D4.0mm_P2.00mm
VCA_IC_1: Opamp_Dual; DIP-8_W7.62mm
VCA_R1: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
VCA_R2: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
VCA_R3, VCA_R5: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
VCA_R4, VCA_R6, VCA_R7: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
VR2, VR7: 50K(B); PTV1113420AA103
VR3, VR5: 50K(A); PTV1113420AA103
VR4: 50K(B)2連; PTV1124420AA504
VR6: 1M(A); PTV1113420AA103
VR8: 10K(B); PTV1113420AA103

Connections:
A+5.333V: D31.1 (K), IC11.6 (-), IC11_1.3 (+), IC11_1.6 (-), J1.2, J5.2, Q26.2 (B1), R36.2, R65.2, R66.1, R68.2, R100.2, R100_1.2, R101.1, R116.1, R117.1, R126.2, TM4.1 (CCW), VCA_IC_1.6 (-), VCA_R1.2, VR2.3 (CW)
A+12V: C72.1, IC11.8 (V+), IC11_1.8 (V+), IC12.14 (VDD), IC15.7 (V+), J1.1, J5.1, Q18.2 (C), Q27.1 (E), Q28.1 (D), Q40.2 (C), Q41.2 (C), R45.1, R92.2, R93.2, R95.1, R103.1, R123.1, R139.1, R142.2, R147.1, R149.1, R150.1, TM4.3 (CW), VCA_IC_1.8 (V+), VCA_R6.1, VR3.3 (CW)
A+CV: IC11.3 (+), IC12.2, J2.1
A+ENV.MOD: IC12.9, J8.1, Q39.1 (D), Q40.1 (E), VR5.3 (CW)
A+ENV_Trig: C54.2, Q37.2 (C), R143.2
A+LineOut: J4.1, VR8.2 (WIPER)
A+VCA-Reso_ACC: D24.2 (A), J7.1, J8.2, R119.2, VR7.2 (WIPER)
A+VCA_Control: IC15.5 (BIAS), VCA_R5.1
A+VCA_Env: D36.2 (A), D37.2 (A), J7.3, Q38.2 (C), R151.1
A+VCA_Resonance: C15.2, C20.1, J3.2, VR4.A2 (WIPER_1)
A+VCA_Signal: C14.2, C21.1, J3.1, VR4.A3 (CW_1)
A+VCA_Trig: D35.2 (A), J7.2, Q36.2 (C), R145.2
A+VCO_CV: D31.2 (A), D32.1 (K), IC11.1, IC12.3, J9.1, R107.2, TM5.3 (CW)
A+VCO_SAW: C10.2, Q28.3 (S), R35.2, R105.1, SW1.3
A+VCO_SQU: Q8.2 (C), R36.1, SW1.1
A+VCO_WAVE: J13.1, R62.2, SW1.2 (2_Comm)
D+GATE: J2.4, R146.1
D+SLIDE: J2.2, R59.1
D-ACC: J2.3, R141.1
GNDA: C11.2, C13.2, C16.2, C22.2, C28.2, C29.2, C30.2, C33.1, C35.2, C36.1, C37.2, C41.1, C42.2, C55.2, C62.2, D26.1 (K), D32.2 (A), IC11.4 (V-), IC11_1.4 (V-), IC12.7 (VSS), IC15.4 (V-), J1.3, J4.2, J5.3, Q9.2 (C), Q29.1 (E), Q30.1 (E), Q35.1 (E), Q37.1 (E), Q39.2 (G), Q39.3 (S), R64.2, R94.2, R96.2, R105.2, R108.2, R109.2, R130.2, R140.2, R144.1, R145.1, R151.2, SW1.MH1, SW1.MH2, VCA_IC_1.4 (V-), VCA_R4.2, VCA_R7.2, VR2.1 (CCW), VR2.MH1, VR2.MH2, VR3.MH1, VR3.MH2, VR4.A1 (CCW_1), VR4.MH1, VR4.MH2, VR5.MH1, VR5.MH2, VR6.MH1, VR6.MH2, VR7.1 (CCW), VR7.MH1, VR7.MH2, VR8.1 (CCW), VR8.MH1, VR8.MH2
unnamed: C10.1, R34.2
unnamed: C15.1, R67.2
unnamed: C16.1, R68.1, R70.2, R98.2
unnamed: C17.1, R62.1
unnamed: C20.2, R122.2
unnamed: C21.2, R121.2
unnamed: C22.1, R66.2, R99.1
unnamed: C23.1, R97.1
unnamed: C29.1, R112.1, R113.2, R114.2, R116.2
unnamed: C34.2, IC11_1.1, R104.2
unnamed: C35.1, IC12.1, IC12.4
unnamed: C36.2, R119.1, R120.2
unnamed: C37.1, R124.2, R125.2, R126.1
unnamed: C54.1, R148.2
unnamed: D24.1 (K), R46.2
unnamed: D25.2 (A), Q27.2 (C)
unnamed: D25.1 (K), Q24.2 (C), Q24.3 (B), Q25.3 (B)
unnamed: D26.2 (A), D29.1 (K), R117.2
unnamed: D27.2 (A), R120.1
unnamed: D27.1 (K), Q31.2 (C), VCA_R5.2
unnamed: D28.2 (A), IC12.10, VR6.2 (WIPER), VR6.3 (CW)
unnamed: D28.1 (K), D29.2 (A)
unnamed: D35.1 (K), R133.2
unnamed: D36.1 (K), R134.2
unnamed: D37.1 (K), R152.2
unnamed: IC11.2 (-), R107.1
unnamed: IC11.5 (+), IC11.7
unnamed: C34.1, IC11_1.2 (-), Q26.6 (C1), R102.1, R103.2
unnamed: IC11_1.5 (+), IC11_1.7
unnamed: IC15.3 (+), R121.1, R122.1, R124.1
unnamed: IC15.2 (-), R125.1
unnamed: IC15.6, VCA_C_2.1
unnamed: Q8.3 (B), R34.1, R35.1
unnamed: C11.1, Q8.1 (E), R45.2
unnamed: Q9.3 (B), R64.1, R65.1
unnamed: Q10.3 (B), R63.2, R71.1, R72.2
unnamed: Q9.1 (E), Q10.2 (C), Q11.1 (E), R47.2, R61.2, R71.2
unnamed: Q10.1 (E), Q11.3 (B), R73.2
unnamed: Q11.2 (C), R69.1
unnamed: C17.2, Q12.2 (B1), R70.1
unnamed: Q12.5 (B2), R97.2, R98.1
unnamed: C18.1, Q12.6 (C1), Q13.1 (E)
unnamed: C18.2, Q12.3 (C2), Q15.1 (E)
unnamed: Q12.1 (E1), Q12.4 (E2), R69.2
unnamed: C19.1, Q13.2 (C), Q13.3 (B), Q14.1 (E)
unnamed: C24.1, Q14.2 (C), Q14.3 (B), Q16.1 (E)
unnamed: C19.2, Q15.2 (C), Q15.3 (B), Q17.1 (E)
unnamed: C25.1, C26.1, Q16.2 (C), Q16.3 (B), Q22.1 (E1)
unnamed: C24.2, Q17.2 (C), Q17.3 (B), Q23.1 (E)
unnamed: Q18.3 (B), R67.1, R99.2
unnamed: C23.2, Q18.1 (E), R94.1
unnamed: Q19.3 (B), Q21.3 (C2), R110.2
unnamed: C28.1, Q19.2 (C), Q22.3 (C2), Q22.6 (C1), R95.2, R110.1, R111.1, R115.1
unnamed: C14.1, Q19.1 (E), R96.1
unnamed: Q20.3 (B), R109.1, R112.2
unnamed: Q20.2 (C), Q21.1 (E1), Q21.4 (E2)
unnamed: Q20.1 (E), R108.1
unnamed: C27.2, Q21.2 (B1), R113.1
unnamed: C25.2, Q21.5 (B2), R114.1
unnamed: Q21.6 (C1), R111.2
unnamed: C30.1, Q22.2 (B1), Q22.5 (B2), R115.2
unnamed: C26.2, C27.1, Q22.4 (E2), Q23.2 (C), Q23.3 (B)
unnamed: Q24.1 (E), R101.2
unnamed: Q25.2 (C), Q27.3 (B)
unnamed: C33.2, Q25.1 (E), Q26.3 (C2), Q28.2 (G)
unnamed: Q26.5 (B2), R100.1, R100_1.1, R106.1, R118.2
unnamed: Q26.1 (E1), Q26.4 (E2), R104.1
unnamed: Q29.3 (B), R59.2
unnamed: IC12.5, Q29.2 (C), R91.1, R92.1
unnamed: Q30.3 (B), R91.2
unnamed: IC12.13, Q30.2 (C), R93.1
unnamed: C42.1, Q31.3 (B), R123.2, R132.1
unnamed: Q31.1 (E), R131.1
unnamed: C41.2, Q32.3 (B), R134.1
unnamed: Q32.2 (C), R132.2
unnamed: Q32.1 (E), R130.1
unnamed: Q35.3 (B), R140.1, R141.2
unnamed: IC12.6, IC12.12, Q35.2 (C), R139.2
unnamed: C72.2, Q36.3 (B), R142.1, R143.1
unnamed: Q36.1 (E), R147.2
unnamed: Q37.3 (B), R144.2, R146.2
unnamed: Q38.3 (B), R148.1, R149.2
unnamed: C55.1, Q38.1 (E), R150.2
unnamed: Q40.3 (B), Q41.1 (E)
unnamed: C62.1, Q41.3 (B), R138.2, R152.1
unnamed: R131.2, R133.1
unnamed: R73.1, TM3.1 (CCW), TM3.2 (WIPER)
unnamed: TM3.3 (CW), VR3.2 (WIPER)
unnamed: R102.2, TM4.2 (WIPER)
unnamed: R106.2, TM5.1 (CCW), TM5.2 (WIPER)
unnamed: VCA_C_1.1, VCA_R2.1
unnamed: VCA_IC_1.1, VCA_R2.2, VCA_R3.1
unnamed: VCA_C_2.2, VCA_IC_1.3 (+), VCA_R6.2, VCA_R7.1
unnamed: VCA_IC_1.2 (-), VCA_R1.1, VCA_R3.2
unnamed: VCA_IC_1.5 (+), VCA_IC_1.7
unnamed: R118.1, VR2.2 (WIPER)
unnamed: R47.1, VR3.1 (CCW)
unnamed: R46.1, VR4.B1 (CCW_2)
unnamed: C13.1, VR4.B3 (CW_2)
unnamed: R72.1, VR4.B2 (WIPER_2)
unnamed: R61.1, VR5.1 (CCW)
unnamed: R63.1, VR5.2 (WIPER)
unnamed: IC12.11, R138.1, VR6.1 (CCW)
unnamed: IC12.8, VR7.3 (CW)
unnamed: VCA_C_1.2, VCA_R4.1, VR8.3 (CW)

## KiCad design TBSEQ_Board_V1/controll/controll.kicad_pcb

Parts:
J3, J4, J5, J6: MJ-3536N; MJ3536N; Manufacturer_Part_Number MJ-3536N; Mouser Part Number 490-MJ-3536N

Connections:
GNDD: J3.1, J4.1, J5.1, J6.1; also elsewhere on the board

Notes on the sheet:
3.5mm mono jack

Parts:
C7: 0.047uF; C_Rect_L7.0mm_W2.5mm_P5.00mm
R2: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 5.1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U2: LM358; DIP-8_W7.62mm

Connections:
D+5V: U2.8 (V+); also elsewhere on the board
D+CV_PWM: R2.1; also elsewhere on the board
GNDD: C7.2, R3.2, U2.4 (V-); also elsewhere on the board
unnamed 127: C7.1, R2.2, U2.3 (+); also elsewhere on the board
unnamed: U2.1, U2.2 (-), U2.5 (+)
unnamed: R3.1, R4.1, U2.6 (-)

Notes on the sheet:
CV PMW to DAC Convert

Parts:
C1: 0.1uF Film; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C2, C3, C4, C5: 0.1uF PC; C_Disc_D5.1mm_W3.2mm_P5.00mm
IC1, IC2: MCP23017-E_SP; DIP794W56P254L3486H508Q28N; Manufacturer_Part_Number MCP23017-E/SP; Mouser Part Number 579-MCP23017-E/SP
IC3: TBD62083APG; DIP926W55P254L2286H480Q18N; Manufacturer_Part_Number TBD62083APG; Mouser Part Number 757-TBD62083APG
IC4: TBD62783APG; DIP762W55P254L2286H480Q18N; Manufacturer_Part_Number TBD62783APG; Mouser Part Number 757-TBD62783APG
R1, R9, R10, R11: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R12: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RN1: R_Network08; R_Array_SIP9

Connections:
/SwitchBox/LED_A0: IC2.21 (GPA0), IC4.1 (I1)
/SwitchBox/LED_A1: IC2.22 (GPA1), IC4.2 (I2)
/SwitchBox/LED_A2: IC2.23 (GPA2), IC4.3 (I3)
/SwitchBox/LED_A3: IC2.24 (GPA3), IC4.4 (I4)
/SwitchBox/LED_B0: IC2.8 (GPB7), IC3.1 (INPUT_1)
/SwitchBox/LED_B1: IC2.7 (GPB6), IC3.2 (INPUT_2)
/SwitchBox/LED_B2: IC2.6 (GPB5), IC3.3 (INPUT_3)
/SwitchBox/LED_B3: IC2.5 (GPB4), IC3.4 (INPUT_4)
/SwitchBox/LED_B4: IC2.4 (GPB3), IC3.5 (INPUT_5)
/SwitchBox/LED_B5: IC2.3 (GPB2), IC3.6 (INPUT_6)
/SwitchBox/LED_B6: IC2.2 (GPB1), IC3.7 (INPUT_7)
/SwitchBox/LED_B7: IC2.1 (GPB0), IC3.8 (INPUT_8)
/SwitchBox/LedCol0: IC3.18 (OUTPUT_1)
/SwitchBox/LedCol1: IC3.17 (OUTPUT_2)
/SwitchBox/LedCol2: IC3.16 (OUTPUT_3)
/SwitchBox/LedCol3: IC3.15 (OUTPUT_4)
/SwitchBox/LedCol4: IC3.14 (OUTPUT_5)
/SwitchBox/LedCol5: IC3.13 (OUTPUT_6)
/SwitchBox/LedCol6: IC3.12 (OUTPUT_7)
/SwitchBox/LedCol7: IC3.11 (OUTPUT_8)
/SwitchBox/LedRow0: R1.2
/SwitchBox/LedRow1: R9.2
/SwitchBox/LedRow2: R10.2
/SwitchBox/LedRow3: R11.2
/SwitchBox/SwCol0: IC1.8 (GPB7)
/SwitchBox/SwCol1: IC1.7 (GPB6)
/SwitchBox/SwCol2: IC1.6 (GPB5)
/SwitchBox/SwCol3: IC1.5 (GPB4)
/SwitchBox/SwCol4: IC1.4 (GPB3)
/SwitchBox/SwCol5: IC1.3 (GPB2)
/SwitchBox/SwCol6: IC1.2 (GPB1)
/SwitchBox/SwCol7: IC1.1 (GPB0)
/SwitchBox/SwRow0: IC1.21 (GPA0), RN1.9 (R8)
/SwitchBox/SwRow1: IC1.22 (GPA1), RN1.8 (R7)
/SwitchBox/SwRow2: IC1.23 (GPA2), RN1.7 (R6)
/SwitchBox/SwRow3: IC1.24 (GPA3), RN1.6 (R5)
D+3.3V: C2.1, C3.1, IC1.9 (VDD), IC2.9 (VDD), IC2.15 (A0), R12.1, RN1.1 (common); also elsewhere on the board
D+5V: C4.1, C5.1, IC3.10 (COMMON), IC4.9 (VCC); also elsewhere on the board
D+MCP_RESET: C1.1, IC1.18 (~RESET), IC2.18 (~RESET), R12.2
D_I2C_SCL: IC1.12 (SCL), IC2.12 (SCL); also elsewhere on the board
D_I2C_SDA: IC1.13 (SDA), IC2.13 (SDA); also elsewhere on the board
GNDD: C1.2, C2.2, C3.2, C4.2, C5.2, IC1.10 (VSS), IC1.15 (A0), IC1.16 (A1), IC1.17 (A2), IC2.10 (VSS), IC2.16 (A1), IC2.17 (A2), IC3.9 (GND), IC4.10 (GND); also elsewhere on the board
unnamed: IC1.25 (GPA4), RN1.5 (R4)
unnamed: IC1.26 (GPA5), RN1.4 (R3)
unnamed: IC1.27 (GPA6), RN1.3 (R2)
unnamed: IC1.28 (GPA7), RN1.2 (R1)
unnamed: IC4.18 (O1), R1.1
unnamed: IC4.17 (O2), R9.1
unnamed: IC4.16 (O3), R10.1
unnamed: IC4.15 (O4), R11.1

Notes on the sheet:
LEDキューブのテスト回路 http://imaturex.blog.fc2.com/blog-entry-18.html ⇒I/Oは3.3V系統だが、TD62083,TD62783は5Vで駆動する必要がある
・LEDに5mA流す場合 TBD62783を通過したので5V=5mA*R R=5/5mA=1000

Parts:
C6: 0.1uF
D65: 1SS120TD; D_A-405_P2.54mm_Vertical_AnodeUp
IC5: TLP2361_V4,E; 11-4L1S(5-PIN-SOIC); Manufacturer_Part_Number TLP2361(V4,E; Mouser Part Number 757-TLP2361V4E
J7: KDJ03-5; KDJ035; Manufacturer_Part_Number KDJ03-5
R13, R14: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections:
A+SyncIn: J7.2; also elsewhere on the board
GNDD: J7.1; also elsewhere on the board
unnamed: C6.1, IC5.6 (VCC), R14.1
unnamed: C6.2, IC5.4 (GND)
unnamed: D65.1 (K), IC5.1 (ANODE), R13.2
unnamed: D65.2 (A), IC5.3 (CATHODE), J7.5
unnamed: IC5.5 (VO_(OUTPUT)), R14.2
unnamed: J7.4, R13.1

Notes on the sheet:
MIDI送受信回路で使うオプトアイソレータはどれが良い？ https://b.meso.tokyo/post/722104583178092544/opt-isolator-selection-guide-for-midi ⇒TLP2361,TLP2304
MIDI Interface(RX only)
