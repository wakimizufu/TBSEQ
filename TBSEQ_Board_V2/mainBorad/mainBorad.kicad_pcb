# Repository wakimizufu/TBSEQ

## KiCad design TBSEQ_Board_V2/mainBorad/mainBorad.kicad_pcb

Parts:
AnPw1: AnPw; PinSocket_1x03_P2.54mm_Vertical
DgJ9, DgJ11, DgJ12, DgJ13: MJ-8435; Manufacturer_Part_Number MJ-8435
DgJ16: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
DgPw1: DgPw; PinSocket_1x03_P2.54mm_Vertical
PanelJ1: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical

Connections:
A+5.333V: AnPw1.2, PanelJ1.14, PanelJ1.21; also elsewhere on the board
A+12V: AnPw1.1, PanelJ1.12, PanelJ1.22; also elsewhere on the board
A+CV: DgJ16.1; also elsewhere on the board
A+CV_MIX: DgJ11.2 (2_1), DgJ11.3 (2_2), DgJ16.2
A+ENV.MOD: PanelJ1.34; also elsewhere on the board
A+GATE: DgJ12.2 (2_1), DgJ12.3 (2_2), DgJ16.5; also elsewhere on the board
A+LineOut: PanelJ1.13; also elsewhere on the board
A+SLIDE: DgJ16.3; also elsewhere on the board
A+SyncOut: DgJ13.2 (2_1), DgJ13.3 (2_2); also elsewhere on the board
A+TEMPO: PanelJ1.1; also elsewhere on the board
A+VCA-Reso_ACC: PanelJ1.38; also elsewhere on the board
A+VCA_Resonance: PanelJ1.25; also elsewhere on the board
A+VCA_Signal: PanelJ1.27; also elsewhere on the board
A+VCO_SAW: PanelJ1.31; also elsewhere on the board
A+VCO_SQU: PanelJ1.29; also elsewhere on the board
A+VCO_WAVE: PanelJ1.33; also elsewhere on the board
A-ACC: DgJ16.4; also elsewhere on the board
A_VR2_WIPER: PanelJ1.19; also elsewhere on the board
A_VR3_CCW: PanelJ1.18; also elsewhere on the board
A_VR3_WIPER: PanelJ1.20; also elsewhere on the board
A_VR4_2_CCW: PanelJ1.24; also elsewhere on the board
A_VR4_2_CW: PanelJ1.28; also elsewhere on the board
A_VR4_2_WIPER: PanelJ1.26; also elsewhere on the board
A_VR5_CCW: PanelJ1.30; also elsewhere on the board
A_VR5_WIPER: PanelJ1.32; also elsewhere on the board
A_VR6_CCW: PanelJ1.35; also elsewhere on the board
A_VR6_WIPER_CW: PanelJ1.37, PanelJ1.39; also elsewhere on the board
A_VR7_CW: PanelJ1.40; also elsewhere on the board
D+3.3V: DgPw1.2, PanelJ1.2; also elsewhere on the board
D+5V: DgPw1.1, PanelJ1.5; also elsewhere on the board
D+5V_SyncIn: DgJ9.2 (2_1), DgJ9.3 (2_2); also elsewhere on the board
D+PlugIn_SyncIn: DgJ9.4 (3); also elsewhere on the board
D_I2C_SCL: PanelJ1.6; also elsewhere on the board
D_I2C_SDA: PanelJ1.4; also elsewhere on the board
GNDA: AnPw1.3, PanelJ1.16, PanelJ1.17, PanelJ1.23, PanelJ1.36; also elsewhere on the board
GNDD: DgJ9.1, DgJ11.1, DgJ12.1, DgJ13.1, DgPw1.3, PanelJ1.7, PanelJ1.8; also elsewhere on the board

Notes on the sheet:
A_VR7_CCWはGNDAと接続
SYNC OUT
A_VR7_WIPERはA+VCA-Reso_ACCと接続
CV OUT
A_VR3_CWはA+12Vと接続
A_VR4_CCW_1はGNDAと接続
A_VR4_1_WIPERはA+VCA_Resonanceと接続
A_VR2_CCWはGNDAと接続
SYNC IN
Interface
GATE OUT
A_VR4_1_CWはA+VCA_Signalと接続
Power
A_VR5_CWはA+ENV.MODと接続
A_VR2_CWはA+5.333Vと接続
A_VR6_WIPERはCWと接続

Parts:
DgC1: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgD1: 1N4148W; D_SOD-123
DgIC4: TLP2304_TPR,E; SOIC127P700X230-6N; Manufacturer_Part_Number TLP2304(TPR,E; Mouser Part Number 757-TLP2304TPRE
DgJ8: KDJ03-5; KDJ035; Manufacturer_Part_Number KDJ03-5
DgR3, DgR4: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
D+5V: DgC1.1, DgIC4.6 (VCC), DgR4.1; also elsewhere on the board
D+5V_MIDIRx: DgIC4.5 (VO_(OUTPUT)), DgR4.2; also elsewhere on the board
GNDD: DgC1.2, DgIC4.4 (GND), DgJ8.MH1, DgJ8.MH2; also elsewhere on the board
unnamed: DgD1.2 (A), DgIC4.3 (CATHODE), DgJ8.5
unnamed: DgD1.1 (K), DgIC4.1 (ANODE), DgR3.2
unnamed: DgJ8.4, DgR3.1

Notes on the sheet:
MIDI送受信回路で使うオプトアイソレータはどれが良い？ https://b.meso.tokyo/post/722104583178092544/opt-isolator-selection-guide-for-midi ⇒TLP2361,TLP2304
MIDI Interface(RX only)
Vcc=5Vで動作確認済(Vcc=3.3Vだと動作できない事も確認した)

Parts:
DgC2: 0.047uF; C_Rect_L7.0mm_W2.5mm_P5.00mm
DgIC5: LM358; SOIC-8_3.9x4.9mm_P1.27mm
DgR5: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
DgR6: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
DgR7: 5.1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical

Connections:
A+CV: DgIC5.7, DgR7.2; also elsewhere on the board
D+5V: DgIC5.8 (V+); also elsewhere on the board
D+CV_PWM: DgR5.1; also elsewhere on the board
GNDD: DgC2.2, DgIC5.4 (V-), DgR6.2; also elsewhere on the board
unnamed: DgC2.1, DgIC5.3 (+), DgR5.2
unnamed: DgIC5.1, DgIC5.2 (-), DgIC5.5 (+)
unnamed: DgIC5.6 (-), DgR6.1, DgR7.1

Notes on the sheet:
CV PMW to DAC Convert

Parts:
DgIC1: FM24CL16B-GTR; SOIC127P602X173-8N; Manufacturer_Part_Number FM24CL16B-GTR; Mouser Part Number 877-FM24CL16B-GTR

Connections:
D+3.3V: DgIC1.8 (VDD); also elsewhere on the board
D_I2C_SCL: DgIC1.6 (SCL); also elsewhere on the board
D_I2C_SDA: DgIC1.5 (SDA); also elsewhere on the board
GNDD: DgIC1.4 (VSS), DgIC1.7 (WP); also elsewhere on the board

Notes on the sheet:
F-RAM 16KByte

Parts:
C10, C33: 0.01uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C11: 1uF/50V; CP_Radial_D5.0mm_P2.00mm
C34: 0.001uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
D25: D; D_A-405_P2.54mm_Vertical_AnodeUp
IC11_1: AN6562; DIP-8_W7.62mm
J13: Conn_01x01_Pin; PinHeader_1x01_P2.54mm_Horizontal
Q8, Q27: PNP; TO-92_HandSolder
Q24, Q25: NPN; TO-92_HandSolder
Q26: HN1C01FU-GR,LF_6P DIP; DIP-6_W7.62mm; Manufacturer_Part_Number HN4A06J(TE85L,F); Mouser Part Number 757-HN4A06JTE85LF
Q28: NJFET; TO-92_HandSolder
R34, R36, R101, R105: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R35, R102, R118: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R45: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R100, R100_1: 1K(TEMPCO); R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R103: 220K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R104: 2.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R106: 27K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
TM4: 50K; 3006P1503LF; Manufacturer_Part_Number 3006P-1-503LF; Mouser Part Number 652-3006P-1-503-LF
TM5: 5K; 3006P1503LF; Manufacturer_Part_Number 3006P-1-503LF; Mouser Part Number 652-3006P-1-503-LF

Connections:
A+5.333V: IC11_1.3 (+), IC11_1.6 (-), Q26.2 (B1), R36.2, R100.2, R100_1.2, R101.1, TM4.3 (CW); also elsewhere on the board
A+12V: IC11_1.8 (V+), Q27.1 (E), Q28.1 (D), R45.1, R103.1, TM4.1 (CCW); also elsewhere on the board
A+VCO_CV: TM5.3 (CW); also elsewhere on the board
A+VCO_SAW: C10.2, Q28.3 (S), R35.2, R105.1; also elsewhere on the board
A+VCO_SQU: Q8.2 (C), R36.1; also elsewhere on the board
A+VCO_WAVE: J13.1; also elsewhere on the board
A_VR2_WIPER: R118.1; also elsewhere on the board
GNDA: C11.2, C33.1, IC11_1.4 (V-), R105.2; also elsewhere on the board
unnamed: C10.1, R34.2
unnamed: C34.2, IC11_1.1, R104.2
unnamed: D25.2 (A), Q27.2 (C)
unnamed: D25.1 (K), Q24.2 (C), Q24.3 (B), Q25.3 (B)
unnamed: C34.1, IC11_1.2 (-), Q26.6 (C1), R102.1, R103.2
unnamed: IC11_1.5 (+), IC11_1.7
unnamed: Q8.3 (B), R34.1, R35.1
unnamed: C11.1, Q8.1 (E), R45.2
unnamed: Q24.1 (E), R101.2
unnamed: Q25.2 (C), Q27.3 (B)
unnamed: C33.2, Q25.1 (E), Q26.3 (C2), Q28.2 (G)
unnamed: Q26.5 (B2), R100.1, R100_1.1, R106.1, R118.2
unnamed: Q26.1 (E1), Q26.4 (E2), R104.1
unnamed: R102.2, TM4.2 (WIPER)
unnamed: R106.2, TM5.1 (CCW), TM5.2 (WIPER)

Notes on the sheet:
最終的にはこれに統一 HN1C01FU_DIP
toVCF
A_VR2_CCWはGNDAと接続
TUNE
TB303_V2では4558で置換
A_VR2_CWはA+5.333Vと接続
WIDTH
TUNING

Parts:
C13, C14, C15, C17, C22, C23, C29: 1uF/50V; CP_Radial_D5.0mm_P2.00mm
C16, C30: 10uF/16V; CP_Radial_D4.0mm_P2.00mm
C18: 0.018uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C19, C24, C26: 0.033uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C25, C27: 0.1uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C28: 47uF/16V; CP_Radial_D4.0mm_P2.00mm
D24: D; D_A-405_P2.54mm_Vertical_AnodeUp
J3: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Horizontal
Q9, Q10: PNP; TO-92_HandSolder
Q11, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q23: NPN; TO-92_HandSolder
Q12, Q21, Q22: HN1C01FU-GR,LF_6P DIP; DIP-6_W7.62mm; Manufacturer_Part_Number HN4A06J(TE85L,F); Mouser Part Number 757-HN4A06JTE85LF
R46: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R47, R61, R64, R65, R94, R96, R97, R109, R112, R115, R116: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R62, R63: 220K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R66, R72, R73, R99, R113, R114: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R67, R68, R69, R70, R71, R98, R108: 2.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R95: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R110, R111: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
TM3: 500K; 3006P1503LF; Manufacturer_Part_Number 3006P-1-503LF; Mouser Part Number 652-3006P-1-503-LF

Connections:
A+5.333V: R65.2, R66.1, R68.2, R116.1; also elsewhere on the board
A+12V: Q18.2 (C), R95.1; also elsewhere on the board
A+VCA-Reso_ACC: D24.2 (A); also elsewhere on the board
A+VCA_Resonance: C15.2, J3.2; also elsewhere on the board
A+VCA_Signal: C14.2, J3.1; also elsewhere on the board
A+VCO_WAVE: R62.2; also elsewhere on the board
A_VR3_CCW: R47.1; also elsewhere on the board
A_VR3_WIPER: TM3.3 (CW); also elsewhere on the board
A_VR4_2_CCW: R46.1; also elsewhere on the board
A_VR4_2_CW: C13.1; also elsewhere on the board
A_VR4_2_WIPER: R72.1; also elsewhere on the board
A_VR5_CCW: R61.1; also elsewhere on the board
A_VR5_WIPER: R63.1; also elsewhere on the board
GNDA: C13.2, C16.2, C22.2, C28.2, C29.2, C30.2, Q9.2 (C), R64.2, R94.2, R96.2, R108.2, R109.2; also elsewhere on the board
unnamed: C15.1, R67.2
unnamed: C16.1, R68.1, R70.2, R98.2
unnamed: C17.1, R62.1
unnamed: C22.1, R66.2, R99.1
unnamed: C23.1, R97.1
unnamed: C29.1, R112.1, R113.2, R114.2, R116.2
unnamed: D24.1 (K), R46.2
unnamed: Q9.3 (B), R64.1, R65.1
unnamed: Q10.3 (B), R63.2, R71.1, R72.2
unnamed: Q9.1 (E), Q10.2 (C), Q11.1 (E), R47.2, R61.2, R71.2
unnamed: Q10.1 (E), Q11.3 (B), R73.2
unnamed: Q11.2 (C), R69.1
unnamed: C17.2, Q12.2 (B1), R70.1
unnamed: Q12.5 (B2), R97.2, R98.1
unnamed: C18.1, Q12.6 (C1), Q13.1 (E)
unnamed: C18.2, Q12.3 (C2), Q15.1 (E)
unnamed: Q12.1 (E1), Q12.4 (E2), R69.2
unnamed: C19.1, Q13.2 (C), Q13.3 (B), Q14.1 (E)
unnamed: C24.1, Q14.2 (C), Q14.3 (B), Q16.1 (E)
unnamed: C19.2, Q15.2 (C), Q15.3 (B), Q17.1 (E)
unnamed: C25.1, C26.1, Q16.2 (C), Q16.3 (B), Q22.1 (E1)
unnamed: C24.2, Q17.2 (C), Q17.3 (B), Q23.1 (E)
unnamed: Q18.3 (B), R67.1, R99.2
unnamed: C23.2, Q18.1 (E), R94.1
unnamed: Q19.3 (B), Q21.3 (C2), R110.2
unnamed: C28.1, Q19.2 (C), Q22.3 (C2), Q22.6 (C1), R95.2, R110.1, R111.1, R115.1
unnamed: C14.1, Q19.1 (E), R96.1
unnamed: Q20.3 (B), R109.1, R112.2
unnamed: Q20.2 (C), Q21.1 (E1), Q21.4 (E2)
unnamed: Q20.1 (E), R108.1
unnamed: C27.2, Q21.2 (B1), R113.1
unnamed: C25.2, Q21.5 (B2), R114.1
unnamed: Q21.6 (C1), R111.2
unnamed: C30.1, Q22.2 (B1), Q22.5 (B2), R115.2
unnamed: C26.2, C27.1, Q22.4 (E2), Q23.2 (C), Q23.3 (B)
unnamed: R73.1, TM3.1 (CCW), TM3.2 (WIPER)

Notes on the sheet:
A+VCA_Signal
最終的にはこれに統一 HN1C01FU_DIP
A_VR4_1_WIPERはA+VCA_Resonanceと接続
RESONANCE
toVCA
CUTOFF.FREQ
FREQ
A_VR3_CWはA+12Vと接続
A_VR5_CWはA+ENV.MODと接続
A_VR4_1_CWはA+VCA_Signalと接続
ENV.MOD
A_VR4_1_CCWはGNDAと接続

Parts:
C35: 0.22uF; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C54: 0.047uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C55: 47uF/16V; CP_Radial_D4.0mm_P2.00mm
C62: 1uF/50V; CP_Radial_D5.0mm_P2.00mm
C72: 10uF/16V; CP_Radial_D4.0mm_P2.00mm
D26, D28, D29, D31, D32, D37: D; D_A-405_P2.54mm_Vertical_AnodeUp
IC11: AN6562; DIP-8_W7.62mm
IC12: 4066; DIP-14_W7.62mm
J7: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Horizontal
J8: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Horizontal
J9: Conn_01x01_Pin; PinHeader_1x01_P2.54mm_Horizontal
Q29, Q30, Q35, Q37, Q40, Q41: NPN; TO-92_HandSolder
Q36, Q38: PNP; TO-92_HandSolder
Q39: NJFET; TO-92_HandSolder
R59, R92, R93, R139, R140, R141: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R91: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R107: 2.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R117, R146, R151: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R138: 68K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R142, R143, R144, R145, R148, R149: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R147, R150: 22; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R152: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical

Connections:
A+5.333V: D31.1 (K), IC11.6 (-), R117.1; also elsewhere on the board
A+12V: C72.1, IC11.8 (V+), IC12.14 (VDD), Q40.2 (C), Q41.2 (C), R92.2, R93.2, R139.1, R142.2, R147.1, R149.1, R150.1; also elsewhere on the board
A+CV: IC11.3 (+), IC12.2; also elsewhere on the board
A+ENV.MOD: IC12.9, J8.1, Q39.1 (D), Q40.1 (E); also elsewhere on the board
A+ENV_Trig: C54.2, Q37.2 (C), R143.2
A+GATE: R146.1; also elsewhere on the board
A+SLIDE: R59.1; also elsewhere on the board
A+VCA-Reso_ACC: J7.1, J8.2; also elsewhere on the board
A+VCA_Env: D37.2 (A), J7.3, Q38.2 (C), R151.1; also elsewhere on the board
A+VCA_Trig: J7.2, Q36.2 (C), R145.2; also elsewhere on the board
A+VCO_CV: D31.2 (A), D32.1 (K), IC11.1, IC12.3, J9.1, R107.2; also elsewhere on the board
A-ACC: R141.1; also elsewhere on the board
A_VR6_CCW: IC12.11, R138.1; also elsewhere on the board
A_VR6_WIPER_CW: D28.2 (A), IC12.10; also elsewhere on the board
A_VR7_CW: IC12.8; also elsewhere on the board
GNDA: C35.2, C55.2, C62.2, D26.1 (K), D32.2 (A), IC11.4 (V-), IC12.7 (VSS), Q29.1 (E), Q30.1 (E), Q35.1 (E), Q37.1 (E), Q39.2 (G), Q39.3 (S), R140.2, R144.1, R145.1, R151.2; also elsewhere on the board
unnamed: C35.1, IC12.1, IC12.4
unnamed: C54.1, R148.2
unnamed: D26.2 (A), D29.1 (K), R117.2
unnamed: D28.1 (K), D29.2 (A)
unnamed: D37.1 (K), R152.2
unnamed: IC11.2 (-), R107.1
unnamed: IC11.5 (+), IC11.7
unnamed: Q29.3 (B), R59.2
unnamed: IC12.5, Q29.2 (C), R91.1, R92.1
unnamed: Q30.3 (B), R91.2
unnamed: IC12.13, Q30.2 (C), R93.1
unnamed: Q35.3 (B), R140.1, R141.2
unnamed: IC12.6, IC12.12, Q35.2 (C), R139.2
unnamed: C72.2, Q36.3 (B), R142.1, R143.1
unnamed: Q36.1 (E), R147.2
unnamed: Q37.3 (B), R144.2, R146.2
unnamed: Q38.3 (B), R148.1, R149.2
unnamed: C55.1, Q38.1 (E), R150.2
unnamed: Q40.3 (B), Q41.1 (E)
unnamed: C62.1, Q41.3 (B), R138.2, R152.1

Notes on the sheet:
Accent
Gate
A_VR6_WIPERはCWと接続
A_VR7_WIPERはA+VCA-Reso_ACCと接続
TB303_V2では4558で置換
Envelope
toVCO
A_VR7_CCWはGNDAと接続
AccentVolume
toVCF
Slide
EnvDecay
toVCA

Parts:
DgC3, DgC4: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgIC2: 74HC126D; SOIC127P600X175-14N; Manufacturer_Part_Number 74HC126D
DgIC3: 74LVC541APW; SOP65P640X110-20N; Manufacturer_Part_Number 74LVC541APW; Mouser Part Number 771-74LVC541APW

Connections:
A+GATE: DgIC2.3 (1Y); also elsewhere on the board
A+SLIDE: DgIC2.6 (2Y); also elsewhere on the board
A+SyncOut: DgIC2.11 (4Y); also elsewhere on the board
A-ACC: DgIC2.8 (3Y); also elsewhere on the board
D+3.3V: DgC4.1, DgIC3.20 (VCC); also elsewhere on the board
D+3.3V_MIDIRX: DgIC3.18 (Y0); also elsewhere on the board
D+5V: DgC3.1, DgIC2.1 (1OE), DgIC2.4 (2OE), DgIC2.10 (3OE), DgIC2.13 (4OE), DgIC2.14 (VCC); also elsewhere on the board
D+5V_MIDIRx: DgIC3.2 (A0); also elsewhere on the board
D+5V_SyncIn: DgIC3.3 (A1); also elsewhere on the board
D+GATE: DgIC2.2 (1A); also elsewhere on the board
D+SLIDE: DgIC2.5 (2A); also elsewhere on the board
D+SyncIn: DgIC3.17 (Y1); also elsewhere on the board
D+SyncOut: DgIC2.12 (4A); also elsewhere on the board
D-ACC: DgIC2.9 (3A); also elsewhere on the board
GNDD: DgC3.2, DgC4.2, DgIC2.7 (GND), DgIC3.1 (~OE1), DgIC3.10 (GND), DgIC3.19 (~OE2); also elsewhere on the board

Notes on the sheet:
3.3V=>5V OutputBuffer
5V=>3.3V InputBuffer

Schematic: RasPico.kicad_sch

Parts:
DgJ2, DgJ3, DgJ4: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
DgJ5: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
DgR1, DgR2: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
DgS1, DgS2: B3F-1000S; B3F1060; Manufacturer_Part_Number B3F-1000S; Mouser Part Number 653-B3F-1000-S
DgU1: Raspberry Pi Pico DIP-40; Raspberry Pi Pico DIP-40_W17.76mm
DgU2: IRLML6402(DIP6Convert); DIP-6_W7.62mm

Connections:
A+TEMPO: DgU1.31 (GP26); also elsewhere on the board
D+3.3V: DgJ5.2, DgR1.1, DgR2.1, DgU1.36 (3V3(OUT)); also elsewhere on the board
D+3.3V_MIDIRX: DgU1.16 (GP12); also elsewhere on the board
D+5V: DgJ5.1, DgU2.2 (Drain); also elsewhere on the board
D+CV_PWM: DgU1.27 (GP21); also elsewhere on the board
D+GATE: DgU1.24 (GP18); also elsewhere on the board
D+PlugIn_SyncIn: DgU1.20 (GP15); also elsewhere on the board
D+SLIDE: DgU1.26 (GP20); also elsewhere on the board
D+SyncIn: DgU1.21 (GP16); also elsewhere on the board
D+SyncOut: DgU1.22 (GP17); also elsewhere on the board
D+VBUS: DgU1.40 (VBUS), DgU2.4 (Gate)
D+VSYS: DgU1.39 (VSYS), DgU2.6 (Source)
D-ACC: DgU1.25 (GP19); also elsewhere on the board
D_I2C_SCL: DgR2.2, DgU1.7 (GP5); also elsewhere on the board
D_I2C_SDA: DgR1.2, DgU1.6 (GP4); also elsewhere on the board
GNDD: DgJ5.6, DgS1.1 (COM_1), DgS1.2 (COM_2), DgS2.1 (COM_1), DgS2.2 (COM_2), DgU1.3 (GND), DgU1.8 (GND), DgU1.13 (GND), DgU1.18 (GND), DgU1.23 (GND), DgU1.28 (GND), DgU1.33 (GND), DgU1.38 (GND); also elsewhere on the board
unnamed: DgJ2.1, DgU1.9 (GP6)
unnamed: DgJ2.2, DgU1.10 (GP7)
unnamed: DgJ2.3, DgU1.11 (GP8)
unnamed: DgJ2.4, DgU1.12 (GP9)
unnamed: DgJ3.1, DgU1.1 (GP0)
unnamed: DgJ3.2, DgU1.2 (GP1)
unnamed: DgJ3.3, DgU1.4 (GP2)
unnamed: DgJ3.4, DgU1.5 (GP3)
unnamed: DgJ4.1, DgU1.14 (GP10)
unnamed: DgJ4.2, DgU1.15 (GP11)
unnamed: DgJ4.3, DgU1.17 (GP13)
unnamed: DgJ4.4, DgU1.19 (GP14)
unnamed: DgJ5.3, DgU1.34 (GP28)
unnamed: DgJ5.4, DgU1.32 (GP27)
unnamed: DgS1.3 (N.O._1), DgS1.4 (N.O._2), DgU1.30 (RUN)
unnamed: DgS2.3 (N.O._1), DgS2.4 (N.O._2), DgU1.29 (GP22)

Notes on the sheet:
ラズパイPico：電池で動作、電池の電圧をOLEDに表示 https://qiita.com/totuto/items/38349e66865d518c45d8
Test Button
USBコネクタ接続時 電流逆流防止
Raspberry Pi Pico Reset Button
Raspberry Pi Pico

Schematic: PowerSupply.kicad_sch

Parts:
PwC1, PwC3: 10uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
PwC2: 1000uF/25V; CP_Radial_D10.0mm_P5.00mm
PwC4, PwC7, PwC9: 0.1uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
PwC5: 470uF/25V; CP_Radial_D5.0mm_P2.50mm
PwC6: 100uF/25V; CP_Radial_D5.0mm_P2.50mm
PwC8: 1uF/25V; CP_Radial_D5.0mm_P2.50mm
PwD1: SBM245L; D_DO-41_SOD81_P5.08mm_Vertical_AnodeUp; Manufacturer_Part_Number SBM245L
PwD2, PwD3: 1N4001; D_DO-41_SOD81_P3.81mm_Vertical_KathodeUp
PwF1, PwF2: MF-R050; MFR050; Manufacturer_Part_Number MF-R050; Mouser Part Number 652-MFR050
PwIC1: BP5293-50; TO254P570X1700X1780-3P; Manufacturer_Part_Number BP5293-50; Mouser Part Number 755-BP5293-50
PwIC2: L7812; TO-220-3_Horizontal_TabDown
PwIC3: LM317LZG; Manufacturer_Part_Number LM317LZG; Mouser Part Number 863-LM317LZG
PwJ1: Barrel_Jack_Switch; BarrelJack_Horizontal
PwJ2, PwJ3, PwJ4, PwJ5: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
PwL1: 4.7uh/0.5A; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
PwR1: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
PwR2: 120; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
PwS1: 4MS1R202M6QES; Manufacturer_Part_Number 4MS1R202M6QES
PwVR1: 3296W-1-101LF; 3296W1502A; Manufacturer_Part_Number 3296W-1-502A; Mouser Part Number 652-3296W-1-502A

Connections:
A+5.333V: PwC8.1, PwD2.2 (A), PwD3.1 (K), PwIC3.2 (VOUT), PwR2.1; also elsewhere on the board
A+12V: PwC6.1, PwC7.1, PwC9.1, PwD1.2 (A), PwD2.1 (K), PwIC2.3 (OUT), PwIC3.3 (VIN); also elsewhere on the board
A+15V: PwC2.1, PwC4.1, PwD1.1 (K), PwF1.2, PwIC2.1 (IN)
A+15VPre: PwF1.1, PwJ4.1
ADAPTER GND: PwJ1.2, PwJ1.3, PwJ2.2, PwJ3.2
ADAPTER+15V: PwJ2.1, PwJ3.1, PwS1.2
D+5V: PwC5.1, PwL1.2; also elsewhere on the board
D+15V: PwF2.2, PwIC1.1 (VIN)
D+15VPre: PwC1.1, PwF2.1, PwJ5.1
GNDA: PwC2.2, PwC4.2, PwC6.2, PwC7.2, PwC8.2, PwC9.2, PwIC2.2 (GND), PwJ4.2, PwR1.2; also elsewhere on the board
GNDD: PwC1.2, PwC3.2, PwC5.2, PwIC1.2 (GND), PwJ5.2; also elsewhere on the board
unnamed: PwD3.2 (A), PwIC3.1 (ADJUST), PwR2.2, PwVR1.2 (WIPER), PwVR1.3 (CW)
unnamed: PwC3.1, PwIC1.3 (VOUT), PwL1.1
unnamed: PwJ1.1, PwS1.1
unnamed: PwR1.1, PwVR1.1 (CCW)

Notes on the sheet:
電圧自在！LM317計算機 https://fukuno.jig.jp/1524 Vin=12V, Vo=5.333V R1=120ohm R2=392ohm⇒R9=330ohm VR1=100ohm
12W級ACアダプター15V0.8A LTE10UW-S3-BS01 https://akizukidenshi.com/catalog/g/g107774/
Analog PowerSupply
BP5293-50の実験 https://brainvision.digick.jp/wordpress/bp5293-50%E3%81%AE%E5%AE%9F%E9%A8%93/
Digital PowerSupply
