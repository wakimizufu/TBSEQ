# Repository wakimizufu/TBSEQ (continued)

## KiCad design TBSEQ_Board_V4/mainBorad/mainBorad_R1.kicad_pcb (continued)

Parts:
VR7: RK09D117000B TEMPO; RK09D117000B; Manufacturer_Part_Number RK09D117000B; Mouser Part Number 688-RK09D117000B

Connections:
A+TEMPO: VR7.2 (WIPER); also elsewhere on the board
D+3.3V: VR7.1 (CCW); also elsewhere on the board
GNDD: VR7.3 (CW), VR7.MH1, VR7.MH2; also elsewhere on the board

Notes on the sheet:
ADC Tempo Volume

Parts:
C1: 2.2uF/25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: RB160M-30TR; RB160M30TR; Manufacturer_Part_Number RB160M-30TR; Mouser Part Number 755-RB160M-30TR
J4: USBPD Unit; PinSocket_1x06_P2.54mm_Vertical
J5: Vin; PinSocket_1x03_P2.54mm_Vertical
JP1: SolderJumper_3_Bridged123; SolderJumper-3_P1.3mm_Bridged123_RoundedPad1.0x1.5mm
PS1: R-78E5.0-0.5; R78E5005; Manufacturer_Part_Number R-78E5.0-0.5; Mouser Part Number 919-R-78E5.0-0.5
PwF1: MF-R050; MFR050; Manufacturer_Part_Number MF-R050; Mouser Part Number 652-MFR050
PwJ1: Barrel_Jack_Switch; BarrelJack_Horizontal
PwS1: 4MS1R202M6QES; Manufacturer_Part_Number 4MS1R202M6QES
R1: 30K; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R2: 24K; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
U1: Opamp_Dual; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
A+5.333V: U1.1, U1.2 (-), U1.5 (+); also elsewhere on the board
A+12V: D1.1 (K), PS1.1 (+VIN), PwF1.2, R1.2, U1.8 (V+); also elsewhere on the board
ADDAPTER GND: J4.1, J4.2, J4.3, JP1.2 (C), PwJ1.2, PwJ1.3
ADDAPTER+12V: J5.1, PwJ1.1
D+5V: D1.2 (A), PS1.3 (+VOUT); also elsewhere on the board
GNDA: C1.2, JP1.1 (A), R2.1, U1.4 (V-); also elsewhere on the board
GNDD: JP1.3 (B), PS1.2 (GND); also elsewhere on the board
unnamed: J5.2, PwS1.1
unnamed: PwF1.1, PwS1.2
unnamed: C1.1, R1.1, R2.2, U1.3 (+)
unnamed: U1.6 (-), U1.7
USBPD+12V: J4.4, J4.5, J4.6, J5.3

Notes on the sheet:
12V
スイッチングACアダプター 12V1A M120100-A010JP https://akizukidenshi.com/catalog/g/g117429/
Analog PowerSupply
CH224 USB-PD電源モジュール(5V,9V,12V,15V,20V対応) https://strawberry-linux.com/support/50224/133127
5.333V
Digital PowerSupply
R-78E5.0-0.5 https://g.recomcdn.com/media/Datasheet/pdf/.fEPvCPZY/.t94eb5dce1c5b51cdcf04/Datasheet-267/R-78-0_5.pdf

Parts:
DgC5, DgC6: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgIC4, DgIC5: 74VHC541D,118; SOIC127P1032X265-20N; Manufacturer_Part_Number 74VHC541D,118; Mouser Part Number 771-74VHC541D118
J1, J2: Conn_01x03; PinSocket_1x03_P2.54mm_Vertical

Connections:
A+GATE: DgIC4.18 (Y0); also elsewhere on the board
A+SLIDE: DgIC4.17 (Y1); also elsewhere on the board
A+SyncOut: DgIC4.15 (Y3), J1.1
A+SyncOut_Run/Stop: DgIC4.14 (Y4), J1.2
A-ACC: DgIC4.16 (Y2); also elsewhere on the board
D+3.3V: DgC6.1, DgIC5.20 (VCC); also elsewhere on the board
D+3.3V_MIDIRX: DgIC5.18 (Y0); also elsewhere on the board
D+3.3V_MIDITX: DgIC4.7 (A5); also elsewhere on the board
D+5V: DgC5.1, DgIC4.20 (VCC); also elsewhere on the board
D+5V_MIDIRx: DgIC5.2 (A0); also elsewhere on the board
D+5V_MIDITX: DgIC4.13 (Y5); also elsewhere on the board
D+5V_SyncIn: DgIC5.3 (A1), J2.1
D+5V_SyncIn_Run/Stop: DgIC5.4 (A2), J2.2
D+GATE: DgIC4.2 (A0); also elsewhere on the board
D+SLIDE: DgIC4.3 (A1); also elsewhere on the board
D+SyncIn: DgIC5.17 (Y1); also elsewhere on the board
D+SyncIn_Run/Stop: DgIC5.16 (Y2); also elsewhere on the board
D+SyncOut: DgIC4.5 (A3); also elsewhere on the board
D+SyncOut_Run/Stop: DgIC4.6 (A4); also elsewhere on the board
D-ACC: DgIC4.4 (A2); also elsewhere on the board
GNDD: DgC5.2, DgC6.2, DgIC4.1 (~OE0), DgIC4.10 (GND), DgIC4.19 (~OE1), DgIC5.1 (~OE0), DgIC5.10 (GND), DgIC5.19 (~OE1), J1.3, J2.3; also elsewhere on the board

Notes on the sheet:
3.3V=>5V OutputBuffer
5V=>3.3V InputBuffer

Parts:
C7: 0.001uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8, C9: 0.01uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10: 1uF/50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D8: 1N4148W; D_SOD-123
IC6: AS321KTR-E1; SOT95P282X145-5N; Manufacturer_Part_Number AS321KTR-E1; Mouser Part Number 621-AS321KTR-E1
J9: VCO_WAVE; PinHeader_1x01_P2.54mm_Vertical
Q11: HN1C01FU-GR,LF; HN1C01FUGRLF; Manufacturer_Part_Number HN4A06J(TE85L,F); Mouser Part Number 757-HN4A06JTE85LF
Q12, Q14: 2SC3325-Y; 2SC3325YLF; Manufacturer_Part_Number 2SC3325-Y
Q13, Q16: 2SA1162-GR_F_; 1SS294LFT; Manufacturer_Part_Number 2SA1162-GR(F)
Q15: 2SK208; SSM3J375FLXHF; Manufacturer_Part_Number 2SK208
R24: 27K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R25, R29, R32: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R26: 1K(TEMPCO); R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R27: 2.2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R28: 220K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R30, R31, R33, R35: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R34: 22K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: 2MS1T1B4VS2QES WAVE; 2MS1T1B4VS2QES; Manufacturer_Part_Number 2MS1T1B4VS2QES; Mouser Part Number N/A
TM1: 3362P-1-502LF WIDTH; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF
TM2: 3362P-1-503LF TUNE; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF
VR3: 50K(B)TUNING; PTV1113420AA103; Manufacturer_Part_Number PTV111-3420A-A103; Mouser Part Number 652-PTV1113420AA103

Connections:
A+5.333V: IC6.1 (INPUT_+), Q11.2 (B1), R26.2, R30.1, R35.2, TM2.1 (CCW), VR3.3 (CW); also elsewhere on the board
A+12V: IC6.5 (VCC), Q13.2 (E), Q15.2 (D), R28.1, R34.1, TM2.3 (CW); also elsewhere on the board
A+VCO_CV: TM1.3 (CW); also elsewhere on the board
A+VCO_SAW: C9.2, Q15.1 (S), R31.1, R32.2, SW1.3
A+VCO_SQU: Q16.3 (C), R35.1, SW1.1
A+VCO_WAVE: J9.1, SW1.2 (2_Comm); also elsewhere on the board
GNDA: C8.1, C10.2, IC6.2 (VEE), R31.2, SW1.MH1, SW1.MH2, VR3.1 (CCW), VR3.MH1, VR3.MH2; also elsewhere on the board
unnamed: C9.1, R33.2
unnamed: D8.2 (A), Q13.3 (C)
unnamed: D8.1 (K), Q12.1 (B), Q14.1 (B), Q14.3 (C)
unnamed: C7.1, IC6.3 (INPUT_-), Q11.6 (C1), R28.2, R29.1
unnamed: C7.2, IC6.4 (OUTPUT), R27.2
unnamed: Q11.5 (B2), R24.1, R25.2, R26.1
unnamed: C8.2, Q11.3 (C2), Q12.2 (E), Q15.3 (G)
unnamed: Q11.1 (E1), Q11.4 (E2), R27.1
unnamed: Q12.3 (C), Q13.1 (B)
unnamed: Q14.2 (E), R30.2
unnamed: Q16.1 (B), R32.1, R33.1
unnamed: C10.1, Q16.2 (E), R34.2
unnamed: R24.2, TM1.1 (CCW), TM1.2 (WIPER)
unnamed: R29.2, TM2.2 (WIPER)
unnamed: R25.1, VR3.2 (WIPER)

Notes on the sheet:
最終的にはこれに統一 HN1C01FU_DIP
toVCF
TUNE
WIDTH
TUNING

Schematic: Jack.kicad_sch

Parts:
AnPw1: AnPw; PinSocket_1x03_P2.54mm_Vertical
DgJ7: MJ-8435 CV OUT; MJ-8435; Manufacturer_Part_Number MJ-8435
DgJ8: MJ-8435 GATE OUT; MJ-8435; Manufacturer_Part_Number MJ-8435
DgJ9: Interface; PinHeader_1x05_P2.54mm_Vertical
DgPw1: DgPw; PinSocket_1x03_P2.54mm_Vertical
J3: Conn_01x05; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical

Connections:
A+5.333V: AnPw1.2; also elsewhere on the board
A+12V: AnPw1.1; also elsewhere on the board
A+CV: DgJ9.1; also elsewhere on the board
A+GATE: DgJ8.2 (2_1), DgJ8.3 (2_2), DgJ9.5; also elsewhere on the board
A+SLIDE: DgJ9.3; also elsewhere on the board
A+VCO_CV: DgJ7.2 (2_1), DgJ7.3 (2_2), DgJ9.2; also elsewhere on the board
A-ACC: DgJ9.4; also elsewhere on the board
D+3.3V: DgPw1.2, J3.1; also elsewhere on the board
D+5V: DgPw1.1; also elsewhere on the board
D_I2C_SCL: J3.3; also elsewhere on the board
D_I2C_SDA: J3.2; also elsewhere on the board
GNDA: AnPw1.3; also elsewhere on the board
GNDD: DgJ7.1, DgJ8.1, DgPw1.3, J3.5; also elsewhere on the board

Notes on the sheet:
toPanelBorad
CV OUT
Interface
GATE OUT
Power

Schematic: Interface.kicad_sch

Parts:
C2: 10uF/16V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 0.22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 0.047uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 47uF/16V; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C6: 1uF/50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D2, D3, D4, D5, D6, D7: 1N4148W; D_SOD-123
IC4: AS321KTR-E1; SOT95P282X145-5N; Manufacturer_Part_Number AS321KTR-E1; Mouser Part Number 621-AS321KTR-E1
IC5: 4066; SO-14_3.9x8.65mm_P1.27mm
J7: toVCF; PinHeader_1x02_P2.54mm_Vertical
J8: toVCA; PinHeader_1x03_P2.54mm_Vertical
Q2, Q3, Q4, Q5, Q8, Q9: 2SC3325-Y; 2SC3325YLF; Manufacturer_Part_Number 2SC3325-Y
Q6, Q7: 2SA1162-GR_F_; 1SS294LFT; Manufacturer_Part_Number 2SA1162-GR(F)
Q10: 2SK208; SSM3J375FLXHF; Manufacturer_Part_Number 2SK208
R3, R4, R5, R6, R7, R12: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8, R10, R21: 22K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11, R13, R14, R17, R18, R19: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15: 2.2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16, R20: 22; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R22: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R23: 68K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
VR1: 1M(A)EnvDecay; PTV1113420AA103; Manufacturer_Part_Number PTV111-3420A-A103; Mouser Part Number 652-PTV1113420AA103
VR2: 50K(B)Accent; PTV1113420AA103; Manufacturer_Part_Number PTV111-3420A-A103; Mouser Part Number 652-PTV1113420AA103

Connections:
A+5.333V: D5.1 (K), R10.1; also elsewhere on the board
A+12V: C2.1, IC4.5 (VCC), IC5.14 (VDD), Q8.3 (C), Q9.3 (C), R6.1, R7.2, R12.2, R14.2, R16.1, R19.1, R20.1; also elsewhere on the board
A+CV: IC4.1 (INPUT_+), IC5.2; also elsewhere on the board
A+ENV.MOD: IC5.9, J7.1, Q9.2 (E), Q10.2 (D); also elsewhere on the board
A+ENV_Trig: C4.2, Q5.3 (C), R13.2
A+VCA-Reso_ACC: J7.2, J8.1, VR2.2 (WIPER); also elsewhere on the board
A+VCA_Env: D7.2 (A), J8.3, Q7.3 (C), R21.1; also elsewhere on the board
A+VCA_Trig: J8.2, Q6.3 (C), R17.2; also elsewhere on the board
A+VCO_CV: D5.2 (A), D6.1 (K), IC4.4 (OUTPUT), IC5.3, R15.2; also elsewhere on the board
D+GATE: R8.1; also elsewhere on the board
D+SLIDE: R5.1; also elsewhere on the board
D-ACC: R3.1; also elsewhere on the board
GNDA: C3.2, C5.2, C6.2, D4.1 (K), D6.2 (A), IC4.2 (VEE), IC5.7 (VSS), Q2.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q10.1 (S), Q10.3 (G), R4.2, R11.1, R17.1, R21.2, VR1.MH1, VR1.MH2, VR2.1 (CCW), VR2.MH1, VR2.MH2; also elsewhere on the board
unnamed: C3.1, IC5.1, IC5.4
unnamed: C4.1, R18.2
unnamed: D2.2 (A), IC5.11, VR1.2 (WIPER), VR1.3 (CW)
unnamed: D2.1 (K), D3.2 (A)
unnamed: D3.1 (K), D4.2 (A), R10.2
unnamed: D7.1 (K), R22.2
unnamed: IC4.3 (INPUT_-), R15.1
unnamed: Q2.1 (B), R3.2, R4.1
unnamed: IC5.6, IC5.12, Q2.3 (C), R6.2
unnamed: Q3.1 (B), R5.2
unnamed: IC5.5, Q3.3 (C), R7.1, R9.1
unnamed: Q4.1 (B), R9.2
unnamed: IC5.13, Q4.3 (C), R12.1
unnamed: Q5.1 (B), R8.2, R11.2
unnamed: C2.2, Q6.1 (B), R13.1, R14.1
unnamed: Q6.2 (E), R16.2
unnamed: Q7.1 (B), R18.1, R19.2
unnamed: C5.1, Q7.2 (E), R20.2
unnamed: C6.1, Q8.1 (B), R22.1, R23.2
unnamed: Q8.2 (E), Q9.1 (B)
unnamed: IC5.10, R23.1, VR1.1 (CCW)
unnamed: IC5.8, VR2.3 (CW)

Notes on the sheet:
Accent
Gate
Envelope
toVCF
Slide
EnvDecay
toVCA

Schematic: AudioOut.kicad_sch

Parts:
C38: 1uF/25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
IC7: AS321KTR-E1; SOT95P282X145-5N; Manufacturer_Part_Number AS321KTR-E1; Mouser Part Number 621-AS321KTR-E1
J12: AudioOut; PinHeader_1x02_P2.54mm_Vertical
J13: MJ-8435 AUDIOOUT; MJ-8435; Manufacturer_Part_Number MJ-8435
R89, R90, R92: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R91, R95: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R93: 47K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R94: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
VR9: 10K(A)VOLUME; PTV1113420AA103; Manufacturer_Part_Number PTV111-3420A-A103; Mouser Part Number 652-PTV1113420AA103

Connections:
A+5.333V: R91.1, R92.1; also elsewhere on the board
A+12V: IC7.5 (VCC), R89.2; also elsewhere on the board
DC_OUT: IC7.1 (INPUT_+), R89.1, R90.2, R91.2; also elsewhere on the board
GNDA: IC7.2 (VEE), J12.2, J13.1, R90.1, R95.1, VR9.1 (CCW), VR9.MH1, VR9.MH2; also elsewhere on the board
unnamed: C38.1, R94.2
unnamed: IC7.3 (INPUT_-), R92.2, R93.1
unnamed: IC7.4 (OUTPUT), R93.2, R94.1
unnamed: J12.1, J13.2 (2_1), J13.3 (2_2), VR9.2 (WIPER)
unnamed: C38.2, R95.2, VR9.3 (CW)

Notes on the sheet:
AudioOut

Schematic: CV.kicad_sch

Parts:
DgC3: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgC4: 0.047uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgIC3: LM358; SOIC-8_3.9x4.9mm_P1.27mm
DgR9: 22K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
DgR10: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
DgR11: 5.1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
A+CV: DgIC3.7, DgR11.2; also elsewhere on the board
D+5V: DgC3.1, DgIC3.8 (V+); also elsewhere on the board
D+CV_PWM: DgR9.1; also elsewhere on the board
GNDD: DgC3.2, DgC4.2, DgIC3.4 (V-), DgR10.2; also elsewhere on the board
unnamed: DgC4.1, DgIC3.3 (+), DgR9.2
unnamed: DgIC3.1, DgIC3.2 (-), DgIC3.5 (+)
unnamed: DgIC3.6 (-), DgR10.1, DgR11.1

Notes on the sheet:
CV PMW to DAC Convert

Board: 2 copper layers, 200.0 x 130.3 mm, 257 parts (0 on the bottom side), 179 nets.

Other parts of the board:
DgC1, DgC2: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgD1: 1N4148W; D_SOD-123
DgIC1: TLP2304_TPR,E; SOIC127P700X230-6N
DgIC2: FM24CL16B-GTR; SOIC127P602X173-8N
DgJ4: KDJ03-5 MIDIIN; KDJ035
DgJ5: KDJ03-5 MIDIOUT; KDJ035
DgJ6: KDJ03-5 MIDITHRU; KDJ035
DgR3, DgR4, DgR5, DgR6, DgR7, DgR8: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
IC1, IC2, IC3: 74AHC1G04W5-7; SOT95P285X140-5N
Q1: 2SC3325-Y; 2SC3325YLF

Their connections:
D+3.3V: DgC2.1, DgIC2.8 (VDD); also elsewhere on the board
D+5V: DgC1.1, DgIC1.6 (VCC), DgR4.1, DgR6.1, DgR7.1, IC1.5 (VCC), IC2.5 (VCC), IC3.5 (VCC); also elsewhere on the board
D+5V_MIDIRx: DgIC1.5 (VO_(OUTPUT)), DgR6.2, IC2.2 (A); also elsewhere on the board
D+5V_MIDITX: IC1.2 (A); also elsewhere on the board
D_I2C_SCL: DgIC2.6 (SCL); also elsewhere on the board
D_I2C_SDA: DgIC2.5 (SDA); also elsewhere on the board
GNDD: DgC1.2, DgC2.2, DgIC1.4 (GND), DgIC2.4 (VSS), DgIC2.7 (WP), DgJ4.MH1, DgJ4.MH2, DgJ5.2, DgJ5.MH1, DgJ5.MH2, DgJ6.2, DgJ6.MH1, DgJ6.MH2, IC1.3 (GND), IC2.3 (GND), IC3.3 (GND), Q1.2 (E); also elsewhere on the board
unnamed: DgD1.2 (A), DgIC1.3 (CATHODE), DgJ4.5
unnamed: DgD1.1 (K), DgIC1.1 (ANODE), DgR3.2
unnamed: DgJ4.4, DgR3.1
unnamed: DgJ5.4, DgR4.2
unnamed: DgJ5.5, DgR5.2
unnamed: DgJ6.4, DgR7.2
unnamed: DgJ6.5, DgR8.2
unnamed: IC1.4 (Y), Q1.1 (B)
unnamed: IC2.4 (Y), IC3.2 (A)
unnamed: DgR8.1, IC3.4 (Y)
unnamed: DgR5.1, Q1.3 (C)

## KiCad design testODDT/testODDT.kicad_pcb

Parts:
C6, C9: 1uF; CP_Radial_D5.0mm_P2.50mm
C7: 0.047uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C8: 51pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
D4, D5: D; D_DO-35_SOD27_P7.62mm_Horizontal
J3: input; PinHeader_1x02_P2.54mm_Vertical
J4: output; PinHeader_1x02_P2.54mm_Vertical
R6: 0; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R7: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R8: 4.7K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R9: 51K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R10: 100K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
U2: Opamp_Dual; DIP-8_W7.62mm_Socket_LongPads
VR5: 500KB; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF

Connections:
A+5.333V: R7.2; also elsewhere on the board
GNDA: J3.2, J4.2, R8.2, R10.2, U2.6 (-); also elsewhere on the board
unnamed: C6.2, R6.2
unnamed: C7.2, R8.1
unnamed: C8.1, C9.1, D4.2 (A), D5.1 (K), U2.1, VR5.2 (WIPER), VR5.3 (CW)
unnamed: C7.1, C8.2, D4.1 (K), D5.2 (A), R9.2, U2.2 (-)
unnamed: C6.1, J3.1
unnamed: C9.2, J4.1, R10.1
unnamed: R6.1, R7.1, U2.3 (+)
unnamed: U2.5 (+), U2.7
unnamed: R9.1, VR5.1 (CCW)

Parts:
C22: 0.018uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C23: 0.22uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C24: 47Pf; C_Disc_D5.0mm_W2.5mm_P5.00mm
C25: 0.015uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C26: 1uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
D7, D8, D9: D; D_DO-35_SOD27_P7.62mm_Horizontal
J9: input; PinHeader_1x02_P2.54mm_Vertical
J10: output; PinHeader_1x02_P2.54mm_Vertical
Q3, Q5: 2SK30ATM-GR; TO-92_HandSolder; Manufacturer_Part_Number 2SK30ATM-GR
Q6: 2SA1015; TO-92_HandSolder
R23, R29: 100K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R24, R27: 2.2K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R25: 4.7K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R26: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R28: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
VR4: 200KB; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF

Connections:
+12VA: Q3.3 (D), Q6.1 (E), R24.1; also elsewhere on the board
A+5.333V: R23.2; also elsewhere on the board
GNDA: C23.2, C25.2, J9.2, J10.2, R25.2, R27.2, R29.2; also elsewhere on the board
unnamed: C23.1, R26.2
unnamed: C25.1, C26.1, R28.2
unnamed: C24.2, D7.2 (A), D8.1 (K), Q3.2 (G), R26.1, VR4.3 (CW)
unnamed: C24.1, D7.1 (K), D9.2 (A), Q6.2 (C), R27.1, R28.1, VR4.1 (CCW), VR4.2 (WIPER)
unnamed: D8.2 (A), D9.1 (K)
unnamed: C22.2, J9.1
unnamed: C26.2, J10.1, R29.1
unnamed: Q3.1 (S), Q5.1 (S), R25.1
unnamed: Q5.3 (D), Q6.3 (B), R24.2
unnamed: C22.1, Q5.2 (G), R23.1

Parts:
C1: 0.068uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C2: 100pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3, C4: 0.47uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C5: 0.01uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1, D2, D3: D; D_DO-35_SOD27_P7.62mm_Horizontal
J1: input; PinHeader_1x02_P2.54mm_Vertical
J2: output; PinHeader_1x02_P2.54mm_Vertical
R1: 47K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R2, R3: 100K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R4: 4.7K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R5: 2.2K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
U1: Opamp_Dual; DIP-8_W7.62mm_Socket_LongPads
VR1: 100KB; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF

Connections:
A+5.333V: D2.2 (A), D3.1 (K), R2.1; also elsewhere on the board
GNDA: C3.2, C5.1, D1.2 (A), J1.2, J2.2; also elsewhere on the board
unnamed: C1.1, R1.1, R2.2
unnamed: C3.1, R4.2
unnamed: C4.1, R5.2
unnamed: D1.1 (K), R1.2, U1.3 (+)
unnamed: C4.2, C5.2, D2.1 (K), D3.2 (A), J2.1
unnamed: C1.2, J1.1
unnamed: U1.1, U1.2 (-), U1.5 (+)
unnamed: R3.1, U1.6 (-)
unnamed: R4.1, VR1.1 (CCW)
unnamed: C2.2, R5.1, U1.7, VR1.3 (CW)
unnamed: C2.1, R3.2, VR1.2 (WIPER)

Parts:
C27, C28: 0.047uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C29: 2200pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C30, C31, C32: 4.7uF/16V; CP_Radial_D5.0mm_P2.50mm
D10: D; D_DO-35_SOD27_P7.62mm_Horizontal
J11: input; PinHeader_1x02_P2.54mm_Vertical
J12: output; PinHeader_1x02_P2.54mm_Vertical
Q1, Q7: 2SK30ATM-GR; TO-92_HandSolder; Manufacturer_Part_Number 2SK30ATM-GR
R30: 1M; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R31: 82K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R32, R33, R35: 470K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R34: 2.4K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R36: 390K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R37, R38, R40: 100K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R39: 1.5K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
U3: Opamp_Dual; DIP-8_W7.62mm_Socket_LongPads
VR6: 10KB; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF
VR7: 100KB; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF

Connections:
+12VA: Q1.3 (D), R36.1; also elsewhere on the board
GNDA: C30.2, C32.2, J11.2, J12.2, R30.2, R35.2, R38.1, R40.2, U3.6 (-), VR6.1 (CCW), VR7.1 (CCW); also elsewhere on the board
unnamed: C27.1, R31.1
unnamed: C29.1, R32.1
unnamed: C31.1, R37.2, U3.1
unnamed: D10.2 (A), R39.2
unnamed: C32.1, D10.1 (K), R33.2, R40.1
unnamed: C27.2, J11.1, R30.1
unnamed: J12.1, VR7.2 (WIPER)
unnamed: C30.1, Q1.2 (G), Q7.1 (S), R34.2, VR6.2 (WIPER), VR6.3 (CW)
unnamed: Q1.1 (S), R34.1
unnamed: C28.2, C29.2, Q7.3 (D), R31.2
unnamed: Q7.2 (G), R32.2, R33.1
unnamed: C28.1, R35.1, R36.2, U3.3 (+)
unnamed: R37.1, R38.2, U3.2 (-)
unnamed: U3.5 (+), U3.7
unnamed: C31.2, R39.1, VR7.3 (CW)
