# Repository wakimizufu/TBSEQ

## KiCad design USBPD12VModule/USBPD12VModule.kicad_pcb

Parts:
C1, C7: 1uF 2012; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: SMAJ22A; D_SMA
IC1: FDS4935A; SOIC127P600X175-8N; Manufacturer_Part_Number FDS4935A; Mouser Part Number 512-FDS4935A
J1: 5077CR-16-SMC2-BK-TR; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: FET BusSwitch; PinSocket_1x03_P2.54mm_Vertical
J3: Output; PinSocket_1x04_P2.54mm_Vertical
J4, J5: GND; PinSocket_1x02_P2.54mm_Vertical
JP1, JP2, JP3: SolderJumper_3_Open; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm_NumberLabels
LED1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R1, R9: RK73H2ATTD1002F; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: RK73H2ATTD1001F; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: RK73H2ATTD1003F; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: RK73H2ATTD3001F; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8: RK73BW3ATTE102J; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
U1: CH224K; SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm_ThermalVias

Connections:
12V: C1.1, IC1.7 (D2_1), IC1.8 (D2_2), J3.1, J3.2, R4.2
Con_CC1: J1.A5 (CC1), U1.6 (CC2)
Con_CC2: J1.B5 (CC2), U1.7 (CC1)
GND: C7.2, D1.2 (A2), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J3.3, J3.4, J4.1, J4.2, J5.1, J5.2, JP1.3 (B), JP2.3 (B), JP3.3 (B), LED1.1 (K), U1.11 (GND)
unnamed: C1.2, R2.1
unnamed: IC1.2 (G2), IC1.4 (G1), R1.1, R2.2, R3.2
unnamed: IC1.1 (S2), IC1.3 (S1), R3.1
unnamed: JP1.2 (C), U1.9 (CFG1)
unnamed: JP2.2 (C), U1.2 (CFG2)
unnamed: JP3.2 (C), U1.3 (CFG3)
unnamed: LED1.2 (A), R4.1
unnamed: J1.A7 (D-), J1.B7 (D-), U1.5 (DM)
unnamed: J1.A6 (D+), J1.B6 (D+), U1.4 (DP)
unnamed: R9.1, U1.8 (VBUS)
PG: J2.1, U1.10 (PG)
VBus: D1.1 (A1), IC1.5 (D1_1), IC1.6 (D1_2), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.3, R8.1, R9.2
Vdd: C7.1, JP1.1 (A), JP2.1 (A), JP3.1 (A), R8.2, U1.1 (VDD)
~Enable: J2.2, R1.2

Notes on the sheet:
100K 1/8W 2012
usb-pd-exporter https://github.com/74th/usb-pd-exporter/blob/main/usb_pd_exporter-v1.0.1-semantics.pdf 【005】生成AIと挑戦する、自分だけのオリジナル実験用電源の製作「キミに選んで欲しい～その２～」 https://note.com/asukuro/n/n63dd002e203d
10K 1/8W 2012
1K 1/8W 2012
3K 1/8W 2012
1K/1W 6331(2512)

Board: 2 copper layers, 25.0 x 34.5 mm, 20 parts (0 on the bottom side), 18 nets.

File USBPD12VModule/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C7",0805,2,1uF 2012,
D1,D_SMA,1,SMAJ22A,
IC1,SOIC127P600X175-8N,1,FDS4935A,
J1,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,5077CR-16-SMC2-BK-TR,
J2,PinSocket_1x03_P2.54mm_Vertical,1,FET BusSwitch,
J3,PinSocket_1x04_P2.54mm_Vertical,1,Output,
"J4, J5",PinSocket_1x02_P2.54mm_Vertical,2,GND,
LED1,0805,1,LED,
"R1, R9",0805,2,RK73H2ATTD1002F,
R2,0805,1,RK73H2ATTD1001F,
R3,0805,1,RK73H2ATTD1003F,
R4,0805,1,RK73H2ATTD3001F,
R8,2512,1,RK73BW3ATTE102J,
U1,SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm_ThermalVias,1,CH224K,

## KiCad design TBSEQ_Board_V4/DigitalBorad/mainBorad_R1.kicad_pcb

Parts:
DgJ2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
DgJ3: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical
DgR1, DgR2: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
DgU1: Raspberry Pi Pico DIP-40; Raspberry Pi Pico DIP-40_W17.76mm
DgU2: IRLML6402; SOT-23W_Handsoldering
S1: TS-06104; TS06104; Manufacturer_Part_Number TS-06104

Connections:
A+TEMPO: DgU1.31 (GP26); also elsewhere on the board
D+3.3In1: DgU1.14 (GP10); also elsewhere on the board
D+3.3In2: DgU1.15 (GP11); also elsewhere on the board
D+3.3In3: DgU1.16 (GP12); also elsewhere on the board
D+3.3In4: DgU1.17 (GP13); also elsewhere on the board
D+3.3In5: DgU1.19 (GP14); also elsewhere on the board
D+3.3In6: DgU1.20 (GP15); also elsewhere on the board
D+3.3In7: DgU1.21 (GP16); also elsewhere on the board
D+3.3Out1: DgU1.9 (GP6); also elsewhere on the board
D+3.3Out2: DgU1.10 (GP7); also elsewhere on the board
D+3.3Out3: DgU1.11 (GP8); also elsewhere on the board
D+3.3Out4: DgU1.12 (GP9); also elsewhere on the board
D+3.3V: DgR1.1, DgR2.1, DgU1.36 (3V3(OUT)); also elsewhere on the board
D+3.3V_MIDIRX: DgJ2.2, DgU1.2 (GP1); also elsewhere on the board
D+3.3V_MIDITX: DgJ2.1, DgU1.1 (GP0); also elsewhere on the board
D+5V: DgU2.3 (D); also elsewhere on the board
D+CV_PWM: DgU1.27 (GP21); also elsewhere on the board
D+GATE: DgU1.24 (GP18); also elsewhere on the board
D+SLIDE: DgU1.26 (GP20); also elsewhere on the board
D+VBUS: DgU1.40 (VBUS), DgU2.1 (G)
D+VSYS: DgU1.39 (VSYS), DgU2.2 (S)
D-ACC: DgU1.25 (GP19); also elsewhere on the board
D_I2C_SCL: DgR2.2, DgU1.7 (GP5); also elsewhere on the board
D_I2C_SDA: DgR1.2, DgU1.6 (GP4); also elsewhere on the board
DgJ3_1: DgJ3.1, DgU1.22 (GP17)
DgJ3_2: DgJ3.2, DgU1.29 (GP22)
DgJ3_3: DgJ3.3, DgU1.32 (GP27)
DgJ3_4: DgJ3.4, DgU1.34 (GP28)
GNDD: DgJ3.5, DgU1.3 (GND), DgU1.8 (GND), DgU1.13 (GND), DgU1.18 (GND), DgU1.23 (GND), DgU1.28 (GND), DgU1.33 (GND), DgU1.38 (GND), S1.C1 (NO_1), S1.D1 (NO_2); also elsewhere on the board
unnamed: DgJ2.3, DgU1.4 (GP2)
unnamed: DgJ2.4, DgU1.5 (GP3)
unnamed: DgU1.30 (RUN), S1.A1 (COM_1), S1.B1 (COM_2)

Notes on the sheet:
ラズパイPico：電池で動作、電池の電圧をOLEDに表示 https://qiita.com/totuto/items/38349e66865d518c45d8
USBコネクタ接続時 電流逆流防止
Raspberry Pi Pico Reset Button
Raspberry Pi Pico

Parts:
J4: Conn_01x03; PinSocket_1x03_P2.54mm_Vertical

Connections:
A+TEMPO: J4.2; also elsewhere on the board
D+3.3V: J4.1; also elsewhere on the board
GNDD: J4.3; also elsewhere on the board

Notes on the sheet:
WIPER
ADC Tempo Volume
CCW

Parts:
C1: 2.2uF/25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: RB160M-30TR; RB160M30TR; Manufacturer_Part_Number RB160M-30TR; Mouser Part Number 755-RB160M-30TR
JP2: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
PS1: R-78E5.0-0.5; R78E5005; Manufacturer_Part_Number R-78E5.0-0.5; Mouser Part Number 919-R-78E5.0-0.5
PwS1: 4MS1R202M6QES; Manufacturer_Part_Number 4MS1R202M6QES
R1: 30K; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R2: 24K; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
U1: Opamp_Dual; SOIC-8_3.9x4.9mm_P1.27mm
U2: USB PD Module; USB_PD_Module

Connections:
A+5.333V: U1.1, U1.2 (-), U1.5 (+); also elsewhere on the board
A+12V: D1.1 (K), PS1.1 (+VIN), R1.2, U1.8 (V+), U2.3 (Output), U2.4 (Output); also elsewhere on the board
D+5V: D1.2 (A), PS1.3 (+VOUT); also elsewhere on the board
GNDA: C1.2, JP2.2 (B), R2.1, U1.4 (V-), U2.1 (GND), U2.2 (GND), U2.8 (GND), U2.9 (GND), U2.10 (GND), U2.11 (GND); also elsewhere on the board
GNDD: JP2.1 (A), PS1.2 (GND); also elsewhere on the board
unnamed: C1.1, R1.1, R2.2, U1.3 (+)
unnamed: U1.6 (-), U1.7
unnamed: PwS1.2, U2.6 (COM)
unnamed: PwS1.1, U2.5 (OFF)
unnamed: PwS1.3, U2.7 (ON)

Notes on the sheet:
12V
Analog PowerSupply
5.333V
Digital PowerSupply
R-78E5.0-0.5 https://g.recomcdn.com/media/Datasheet/pdf/.fEPvCPZY/.t94eb5dce1c5b51cdcf04/Datasheet-267/R-78-0_5.pdf

Parts:
DgC5, DgC6: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgIC4, DgIC5: 74VHC541FT; SOP65P640X120-20N; Manufacturer_Part_Number 74VHC541FT; Mouser Part Number N/A
J1, J2: Conn_01x08; PinSocket_1x08_P2.54mm_Vertical

Connections:
A+GATE: DgIC4.18 (Y1), J2.1; also elsewhere on the board
A+SLIDE: DgIC4.17 (Y2), J2.2; also elsewhere on the board
A-ACC: DgIC4.16 (Y3), J2.3; also elsewhere on the board
D+3.3In1: DgIC5.18 (Y1); also elsewhere on the board
D+3.3In2: DgIC5.17 (Y2); also elsewhere on the board
D+3.3In3: DgIC5.16 (Y3); also elsewhere on the board
D+3.3In4: DgIC5.15 (Y4); also elsewhere on the board
D+3.3In5: DgIC5.14 (Y5); also elsewhere on the board
D+3.3In6: DgIC5.13 (Y6); also elsewhere on the board
D+3.3In7: DgIC5.12 (Y7); also elsewhere on the board
D+3.3Out1: DgIC4.5 (A4); also elsewhere on the board
D+3.3Out2: DgIC4.6 (A5); also elsewhere on the board
D+3.3Out3: DgIC4.7 (A6); also elsewhere on the board
D+3.3Out4: DgIC4.8 (A7); also elsewhere on the board
D+3.3V: DgC6.1, DgIC5.20 (VCC); also elsewhere on the board
D+3.3V_MIDIRX: DgIC5.11 (Y8); also elsewhere on the board
D+3.3V_MIDITX: DgIC4.9 (A8); also elsewhere on the board
D+5.0In1: DgIC5.2 (A1), J1.1
D+5.0In2: DgIC5.3 (A2), J1.2
D+5.0In3: DgIC5.4 (A3), J1.3
D+5.0In4: DgIC5.5 (A4), J1.4
D+5.0In5: DgIC5.6 (A5), J1.5
D+5.0In6: DgIC5.7 (A6), J1.6
D+5.0In7: DgIC5.8 (A7), J1.7
D+5.0Out1: DgIC4.15 (Y4), J2.4
D+5.0Out2: DgIC4.14 (Y5), J2.5
D+5.0Out3: DgIC4.13 (Y6), J2.6
D+5.0Out4: DgIC4.12 (Y7), J2.7
D+5V: DgC5.1, DgIC4.20 (VCC); also elsewhere on the board
D+5V_MIDIRx: DgIC5.9 (A8); also elsewhere on the board
D+5V_MIDITX: DgIC4.11 (Y8); also elsewhere on the board
D+GATE: DgIC4.2 (A1); also elsewhere on the board
D+SLIDE: DgIC4.3 (A2); also elsewhere on the board
D-ACC: DgIC4.4 (A3); also elsewhere on the board
GNDD: DgC5.2, DgC6.2, DgIC4.1 (~G1), DgIC4.10 (GND), DgIC4.19 (~G2), DgIC5.1 (~G1), DgIC5.10 (GND), DgIC5.19 (~G2), J1.8, J2.8; also elsewhere on the board

Notes on the sheet:
3.3V=>5V OutputBuffer
5V=>3.3V InputBuffer

Parts:
DgC1: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgD1: 1N4148W; D_SOD-123
DgIC1: TLP2304_TPR,E; SOIC127P700X230-6N; Manufacturer_Part_Number TLP2304(TPR,E; Mouser Part Number 757-TLP2304TPRE
DgJ4: KDJ03-5 MIDIIN; KDJ035; Manufacturer_Part_Number KDJ03-5
DgJ5: KDJ03-5 MIDIOUT; KDJ035; Manufacturer_Part_Number KDJ03-5
DgJ6: KDJ03-5 MIDITHRU; KDJ035; Manufacturer_Part_Number KDJ03-5
DgR3, DgR4, DgR5, DgR6, DgR7, DgR8: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
IC1, IC2, IC3: 74AHC1G04W5-7; SOT95P285X140-5N; Manufacturer_Part_Number 74AHC1G04W5-7; Mouser Part Number 621-74AHC1G04W5-7
Q1: 2SC3325-Y; 2SC3325YLF; Manufacturer_Part_Number 2SC3325-Y

Connections:
D+5V: DgC1.1, DgIC1.6 (VCC), DgR4.1, DgR6.1, DgR7.1, IC1.5 (VCC), IC2.5 (VCC), IC3.5 (VCC); also elsewhere on the board
D+5V_MIDIRx: DgIC1.5 (VO_(OUTPUT)), DgR6.2, IC2.2 (A); also elsewhere on the board
D+5V_MIDITX: IC1.2 (A); also elsewhere on the board
GNDD: DgC1.2, DgIC1.4 (GND), DgJ4.MH1, DgJ4.MH2, DgJ5.2, DgJ5.MH1, DgJ5.MH2, DgJ6.2, DgJ6.MH1, DgJ6.MH2, IC1.3 (GND), IC2.3 (GND), IC3.3 (GND), Q1.2 (E); also elsewhere on the board
unnamed: DgD1.2 (A), DgIC1.3 (CATHODE), DgJ4.5
unnamed: DgD1.1 (K), DgIC1.1 (ANODE), DgR3.2
unnamed: DgJ4.4, DgR3.1
unnamed: DgJ5.4, DgR4.2
unnamed: DgJ5.5, DgR5.2
unnamed: DgJ6.4, DgR7.2
unnamed: DgJ6.5, DgR8.2
unnamed: IC1.4 (Y), Q1.1 (B)
unnamed: IC2.4 (Y), IC3.2 (A)
unnamed: DgR8.1, IC3.4 (Y)
unnamed: DgR5.1, Q1.3 (C)

Notes on the sheet:
MIDI送受信回路で使うオプトアイソレータはどれが良い？ https://b.meso.tokyo/post/722104583178092544/opt-isolator-selection-guide-for-midi ⇒TLP2361,TLP2304
MIDI Interface RxThru
MIDI Interface Tx
MIDI Interface Rx
MIDI 1.0 規格書 https://amei.or.jp/midistandardcommittee/MIDI1.0.pdf
Vcc=5Vで動作確認済(Vcc=3.3Vだと動作できない事も確認した)

Parts:
AnPw1: AnPw; PinSocket_1x03_P2.54mm_Vertical
DgJ7: MJ-8435 CV OUT; MJ-8435; Manufacturer_Part_Number MJ-8435
DgJ8: MJ-8435 GATE OUT; MJ-8435; Manufacturer_Part_Number MJ-8435
DgJ9: Interface; PinHeader_1x05_P2.54mm_Vertical
DgPw1: DgPw; PinSocket_1x03_P2.54mm_Vertical
J3: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical

Connections:
A+5.333V: AnPw1.2; also elsewhere on the board
A+12V: AnPw1.1; also elsewhere on the board
A+CV: DgJ9.1; also elsewhere on the board
A+GATE: DgJ8.2 (2_1), DgJ8.3 (2_2), DgJ9.5; also elsewhere on the board
A+SLIDE: DgJ9.3; also elsewhere on the board
A+VCO_CV: DgJ7.2 (2_1), DgJ7.3 (2_2), DgJ9.2
A-ACC: DgJ9.4; also elsewhere on the board
D+3.3V: DgPw1.2, J3.1; also elsewhere on the board
D+5V: DgPw1.1; also elsewhere on the board
D_I2C_SCL: J3.3; also elsewhere on the board
D_I2C_SDA: J3.2; also elsewhere on the board
GNDA: AnPw1.3; also elsewhere on the board
GNDD: DgJ7.1, DgJ8.1, DgPw1.3, J3.5; also elsewhere on the board

Notes on the sheet:
toPanelBorad
CV OUT
Interface
GATE OUT
Power

Parts:
DgC3: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgC4: 0.047uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgIC3: LM358; SOIC-8_3.9x4.9mm_P1.27mm
DgR9: 22K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
DgR10: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
DgR11: 5.1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
A+CV: DgIC3.7, DgR11.2; also elsewhere on the board
D+5V: DgC3.1, DgIC3.8 (V+); also elsewhere on the board
D+CV_PWM: DgR9.1; also elsewhere on the board
GNDD: DgC3.2, DgC4.2, DgIC3.4 (V-), DgR10.2; also elsewhere on the board
unnamed: DgC4.1, DgIC3.3 (+), DgR9.2
unnamed: DgIC3.1, DgIC3.2 (-), DgIC3.5 (+)
unnamed: DgIC3.6 (-), DgR10.1, DgR11.1

Notes on the sheet:
CV PMW to DAC Convert

Parts:
DgC2: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgIC2: FM24CL16B-GTR; SOIC127P602X173-8N; Manufacturer_Part_Number FM24CL16B-GTR; Mouser Part Number 877-FM24CL16B-GTR

Connections:
D+3.3V: DgC2.1, DgIC2.8 (VDD); also elsewhere on the board
D_I2C_SCL: DgIC2.6 (SCL); also elsewhere on the board
D_I2C_SDA: DgIC2.5 (SDA); also elsewhere on the board
GNDD: DgC2.2, DgIC2.4 (VSS), DgIC2.7 (WP); also elsewhere on the board

Notes on the sheet:
F-RAM 16KByte

Board: 2 copper layers, 152.0 x 51.0 mm, 53 parts (33 on the bottom side), 72 nets.

## KiCad design TBSEQ_Board_V4/rythemPanelBoard/rythemPanelBoard.kicad_pcb

Parts:
VR1: RK09D117000B; Manufacturer_Part_Number RK09D117000B; Mouser Part Number 688-RK09D117000B

Connections:
A+TEMPO: VR1.2 (WIPER); also elsewhere on the board
GNDD: VR1.MH1, VR1.MH2; also elsewhere on the board
TEMPO_CCW: VR1.1 (CCW); also elsewhere on the board
TEMPO_CW: VR1.3 (CW); also elsewhere on the board
