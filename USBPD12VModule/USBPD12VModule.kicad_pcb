# Repository wakimizufu/TBSEQ (continued)

## KiCad design testODDT/testODDT.kicad_pcb (continued)

Parts:
C15, C18, C19: 10uF/16V; CP_Radial_D5.0mm_P2.50mm
C16, C17, C20: 0.1uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C21: 0.01uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
D6: D; D_DO-35_SOD27_P7.62mm_Horizontal
J7: input; PinHeader_1x02_P2.54mm_Vertical
J8: output; PinHeader_1x02_P2.54mm_Vertical
Q4: 2SK30ATM-GR; TO-92_HandSolder; Manufacturer_Part_Number 2SK30ATM-GR
R14, R15, R16: 100K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R17: 1M; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R18, R22: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R19: 470K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R20, R21: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
U4: Opamp_Dual; DIP-8_W7.62mm_Socket_LongPads
VR3: 5KB; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF

Connections:
+12VA: R15.1, R17.1, R20.1; also elsewhere on the board
GNDA: C15.2, C19.2, C20.2, C21.2, J7.2, J8.2, R16.2, R21.2; also elsewhere on the board
unnamed: C17.2, R19.1, U4.1
unnamed: C18.1, R22.2
unnamed: C20.1, D6.2 (A), R17.2, R18.1
unnamed: D6.1 (K), R14.1, U4.7
unnamed: C16.2, J7.1
unnamed: C17.1, J8.1
unnamed: C18.2, Q4.3 (D)
unnamed: C21.1, Q4.2 (G), R18.2
unnamed: C19.1, Q4.1 (S), R20.2, R21.1
unnamed: C16.1, R15.2, R16.1, U4.3 (+), U4.5 (+)
unnamed: R19.2, R22.1, U4.2 (-)
unnamed: R14.2, U4.6 (-), VR3.3 (CW)
unnamed: C15.1, VR3.1 (CCW), VR3.2 (WIPER)

Parts:
AnPw1: AnalogPower; PinSocket_1x03_P2.54mm_Vertical
U1, U2, U3, U4: Opamp_Dual; DIP-8_W7.62mm_Socket_LongPads

Connections:
+12VA: AnPw1.1, U1.8 (V+), U2.8 (V+), U3.8 (V+), U4.8 (V+); also elsewhere on the board
A+5.333V: AnPw1.2; also elsewhere on the board
GNDA: AnPw1.3, U1.4 (V-), U2.4 (V-), U3.4 (V-), U4.4 (V-); also elsewhere on the board

Parts:
C10, C11: 1uF; CP_Radial_D5.0mm_P2.50mm
C12: 0.047uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C13: 10uF; CP_Radial_D5.0mm_P2.50mm
C14: 470pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
J5: input; PinHeader_1x02_P2.54mm_Vertical
J6: output; PinHeader_1x02_P2.54mm_Vertical
Q2: 2SK30ATM-GR; TO-92_HandSolder; Manufacturer_Part_Number 2SK30ATM-GR
R11: 475K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R12: 499; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R13: 221; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
VR2: 2KB; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF

Connections:
+12VA: C11.1, C12.1, VR2.1 (CCW); also elsewhere on the board
A+5.333V: R11.2; also elsewhere on the board
GNDA: C11.2, C12.2, C13.2, C14.2, J5.2, J6.2, R13.2; also elsewhere on the board
unnamed: C10.1, J5.1
unnamed: C14.1, J6.1, Q2.3 (D), R12.2
unnamed: C10.2, Q2.2 (G), R11.1
unnamed: C13.1, Q2.1 (S), R13.1
unnamed: R12.1, VR2.2 (WIPER), VR2.3 (CW)

Board: 2 copper layers, 100.0 x 100.0 mm, 113 parts (0 on the bottom side), 66 nets.

## KiCad design TBSEQ_Board_V3/mainBorad/mainBorad.kicad_pcb

Schematic: VCF.kicad_sch

Parts:
C13, C14, C15, C17, C22, C23, C29: 1uF/50V; CP_Radial_D4.0mm_P2.00mm
C16, C30: 10uF/16V; CP_Radial_D4.0mm_P2.00mm
C18: 0.018uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C19, C24, C26: 0.033uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C25, C27: 0.1uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C28: 47uF/16V; CP_Radial_D4.0mm_P2.00mm
D24: D; D_A-405_P2.54mm_Vertical_AnodeUp
J3: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
Q9, Q10: PNP; TO-92_HandSolder
Q11, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q23: NPN; TO-92_HandSolder
Q12, Q21, Q22: HN1C01FU-GR,LF; HN1C01FUGRLF; Manufacturer_Part_Number HN4A06J(TE85L,F); Mouser Part Number 757-HN4A06JTE85LF
R46: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R47, R61, R64, R65, R94, R96, R97, R109, R112, R115, R116: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R62, R63: 220K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R66, R72, R73, R99, R113, R114: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R67, R68, R69, R70, R71, R98, R108: 2.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R95: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R110, R111: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
TM3: 500K; 3296W1502A; Manufacturer_Part_Number 3296W-1-502A; Mouser Part Number 652-3296W-1-502A
VR3, VR5: 50K(A); PTV1113420AA103; Manufacturer_Part_Number PTV111-3420A-A103; Mouser Part Number 652-PTV1113420AA103
VR4: 50K(B)2連; PTV1124420AA504; Manufacturer_Part_Number PTV112-4420A-A504; Mouser Part Number 652-PTV1124420AA504

Connections:
A+5.333V: R65.2, R66.1, R68.2, R116.1; also elsewhere on the board
A+12V: Q18.2 (C), R95.1, VR3.3 (CW); also elsewhere on the board
A+ENV.MOD: VR5.3 (CW); also elsewhere on the board
A+VCA-Reso_ACC: D24.2 (A); also elsewhere on the board
A+VCA_Resonance: C15.2, J3.2, VR4.A2 (WIPER_1); also elsewhere on the board
A+VCA_Signal: C14.2, J3.1, VR4.A3 (CW_1); also elsewhere on the board
A+VCO_WAVE: R62.2; also elsewhere on the board
GNDA: C13.2, C16.2, C22.2, C28.2, C29.2, C30.2, Q9.2 (C), R64.2, R94.2, R96.2, R108.2, R109.2, VR3.MH1, VR3.MH2, VR4.A1 (CCW_1), VR4.MH1, VR4.MH2, VR5.MH1, VR5.MH2; also elsewhere on the board
unnamed: C15.1, R67.2
unnamed: C16.1, R68.1, R70.2, R98.2
unnamed: C17.1, R62.1
unnamed: C22.1, R66.2, R99.1
unnamed: C23.1, R97.1
unnamed: C29.1, R112.1, R113.2, R114.2, R116.2
unnamed: D24.1 (K), R46.2
unnamed: Q9.3 (B), R64.1, R65.1
unnamed: Q10.3 (B), R63.2, R71.1, R72.2
unnamed: Q9.1 (E), Q10.2 (C), Q11.1 (E), R47.2, R61.2, R71.2
unnamed: Q10.1 (E), Q11.3 (B), R73.2
unnamed: Q11.2 (C), R69.1
unnamed: C17.2, Q12.2 (B1), R70.1
unnamed: Q12.5 (B2), R97.2, R98.1
unnamed: C18.1, Q12.6 (C1), Q13.1 (E)
unnamed: C18.2, Q12.3 (C2), Q15.1 (E)
unnamed: Q12.1 (E1), Q12.4 (E2), R69.2
unnamed: C19.1, Q13.2 (C), Q13.3 (B), Q14.1 (E)
unnamed: C24.1, Q14.2 (C), Q14.3 (B), Q16.1 (E)
unnamed: C19.2, Q15.2 (C), Q15.3 (B), Q17.1 (E)
unnamed: C25.1, C26.1, Q16.2 (C), Q16.3 (B), Q22.1 (E1)
unnamed: C24.2, Q17.2 (C), Q17.3 (B), Q23.1 (E)
unnamed: Q18.3 (B), R67.1, R99.2
unnamed: C23.2, Q18.1 (E), R94.1
unnamed: Q19.3 (B), Q21.3 (C2), R110.2
unnamed: C28.1, Q19.2 (C), Q22.3 (C2), Q22.6 (C1), R95.2, R110.1, R111.1, R115.1
unnamed: C14.1, Q19.1 (E), R96.1
unnamed: Q20.3 (B), R109.1, R112.2
unnamed: Q20.2 (C), Q21.1 (E1), Q21.4 (E2)
unnamed: Q20.1 (E), R108.1
unnamed: C27.2, Q21.2 (B1), R113.1
unnamed: C25.2, Q21.5 (B2), R114.1
unnamed: Q21.6 (C1), R111.2
unnamed: C30.1, Q22.2 (B1), Q22.5 (B2), R115.2
unnamed: C26.2, C27.1, Q22.4 (E2), Q23.2 (C), Q23.3 (B)
unnamed: R73.1, TM3.1 (CCW), TM3.2 (WIPER)
unnamed: TM3.3 (CW), VR3.2 (WIPER)
unnamed: R47.1, VR3.1 (CCW)
unnamed: R46.1, VR4.B1 (CCW_2)
unnamed: C13.1, VR4.B3 (CW_2)
unnamed: R72.1, VR4.B2 (WIPER_2)
unnamed: R61.1, VR5.1 (CCW)
unnamed: R63.1, VR5.2 (WIPER)

Notes on the sheet:
A+VCA_Signal
最終的にはこれに統一 HN1C01FU_DIP
RESONANCE
toVCA
CUTOFF.FREQ
FREQ
ENV.MOD

Schematic: RasPico.kicad_sch

Parts:
DgJ2: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
DgJ3: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
DgJ5: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
DgR1, DgR2: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
DgS1: B3F-1000S; B3F1060; Manufacturer_Part_Number B3F-1000S; Mouser Part Number 653-B3F-1000-S
DgU1: Raspberry Pi Pico DIP-40; Raspberry Pi Pico DIP-40_W17.76mm
DgU2: IRLML6402; SOT-23W_Handsoldering

Connections:
A+TEMPO: DgU1.31 (GP26); also elsewhere on the board
D+3.3V: DgJ5.2, DgR1.1, DgR2.1, DgU1.36 (3V3(OUT)); also elsewhere on the board
D+3.3V_MIDIRX: DgJ3.2, DgU1.2 (GP1); also elsewhere on the board
D+3.3V_MIDITX: DgJ3.1, DgU1.1 (GP0); also elsewhere on the board
D+5V: DgJ5.1, DgU2.3 (D); also elsewhere on the board
D+CV_PWM: DgU1.27 (GP21); also elsewhere on the board
D+GATE: DgU1.24 (GP18); also elsewhere on the board
D+SLIDE: DgU1.26 (GP20); also elsewhere on the board
D+SyncIn: DgU1.21 (GP16); also elsewhere on the board
D+SyncIn_Run/Stop: DgU1.17 (GP13); also elsewhere on the board
D+SyncOut: DgU1.22 (GP17); also elsewhere on the board
D+SyncOut_Run/Stop: DgU1.19 (GP14); also elsewhere on the board
D+VBUS: DgU1.40 (VBUS), DgU2.1 (G)
D+VSYS: DgU1.39 (VSYS), DgU2.2 (S)
D-ACC: DgU1.25 (GP19); also elsewhere on the board
D_I2C_SCL: DgR2.2, DgU1.7 (GP5); also elsewhere on the board
D_I2C_SDA: DgR1.2, DgU1.6 (GP4); also elsewhere on the board
GNDD: DgJ5.6, DgS1.1 (COM_1), DgS1.2 (COM_2), DgU1.3 (GND), DgU1.8 (GND), DgU1.13 (GND), DgU1.18 (GND), DgU1.23 (GND), DgU1.28 (GND), DgU1.33 (GND), DgU1.38 (GND); also elsewhere on the board
unnamed: DgJ2.1, DgU1.9 (GP6)
unnamed: DgJ2.2, DgU1.10 (GP7)
unnamed: DgJ2.3, DgU1.11 (GP8)
unnamed: DgJ2.4, DgU1.12 (GP9)
unnamed: DgJ2.5, DgU1.14 (GP10)
unnamed: DgJ2.6, DgU1.15 (GP11)
unnamed: DgJ2.7, DgU1.16 (GP12)
unnamed: DgJ2.8, DgU1.20 (GP15)
unnamed: DgJ3.3, DgU1.4 (GP2)
unnamed: DgJ3.4, DgU1.5 (GP3)
unnamed: DgJ5.3, DgU1.34 (GP28)
unnamed: DgJ5.4, DgU1.32 (GP27)
unnamed: DgJ5.5, DgU1.29 (GP22)
unnamed: DgS1.3 (N.O._1), DgS1.4 (N.O._2), DgU1.30 (RUN)

Notes on the sheet:
ラズパイPico：電池で動作、電池の電圧をOLEDに表示 https://qiita.com/totuto/items/38349e66865d518c45d8
USBコネクタ接続時 電流逆流防止
Raspberry Pi Pico Reset Button
Raspberry Pi Pico

Schematic: LM13700_Overdrive.kicad_sch

Parts:
C1, C2: 0.01uF; C_Rect_L7.0mm_W2.0mm_P5.00mm
C3, C4: 10uF/25V; CP_Radial_D5.0mm_P2.50mm
C5: 0.01uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C6, C8, C9: 1uF/25V; CP_Radial_D5.0mm_P2.50mm
C12: 0.1uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C20: 1uF/50V; CP_Radial_D5.0mm_P2.00mm
C21: 0.033uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
D1, D2, D3: D; D_A-405_P2.54mm_Vertical_AnodeUp
J6: MJ-462; MJ462; Manufacturer_Part_Number MJ-462
J12: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
Q1: NPN; TO-92_HandSolder
Q2: PNP; TO-92_HandSolder
R1, R4, R5, R26: 2.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2, R28: 220K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3, R15, R20, R24: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R6, R29: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R7, R12: 33K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R8, R13: 5K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R9, R10: 510; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R11, R17, R22, R25: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R14, R16: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R21, R30: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R23: 1.5K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R27: 1.5M; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
TM1: 10K; 3296W1502A; Manufacturer_Part_Number 3296W-1-502A; Mouser Part Number 652-3296W-1-502A
U1: LM13700; DIP-16_W7.62mm_Socket_LongPads
U4: Opamp_Dual; DIP-8_W7.62mm_LongPads
VCA_R1: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
VR8: 50K(B); PTV1113420AA103; Manufacturer_Part_Number PTV111-3420A-A103; Mouser Part Number 652-PTV1113420AA103
VR9: 10K(A); PTV1113420AA103; Manufacturer_Part_Number PTV111-3420A-A103; Mouser Part Number 652-PTV1113420AA103

Connections:
A+5.333V: C5.2, R1.1, R7.1, R9.1, R10.1, R12.1, R14.2, R15.1, R16.1, U4.5 (+); also elsewhere on the board
A+12V: R27.1, U1.11 (V+), U4.8 (V+); also elsewhere on the board
A+VCA-Reso_ACC: R29.2; also elsewhere on the board
A+VCA_Control: R6.1, VCA_R1.1
A+VCA_Env: D1.2 (A); also elsewhere on the board
A+VCA_Resonance: C2.1; also elsewhere on the board
A+VCA_Signal: C1.1; also elsewhere on the board
A+VCA_Trig: D2.2 (A); also elsewhere on the board
GNDA: C3.2, C12.1, C20.2, C21.1, J6.S1, J6.SS1, J12.2, R8.1, R13.1, R20.1, R22.2, TM1.3 (CW), U1.6 (V-), U4.4 (V-), VR8.MH1, VR8.MH2, VR9.3 (CW), VR9.MH1, VR9.MH2; also elsewhere on the board
unnamed: C1.2, R2.1
unnamed: C2.2, R3.1
unnamed: C3.1, R1.2, R4.1, R5.1
unnamed: C4.2, R11.1
unnamed: C6.1, R17.2
unnamed: C8.1, R8.2, U1.9
unnamed: C21.2, R29.1, R30.2
unnamed: D1.1 (K), R21.2
unnamed: D2.1 (K), R26.2
unnamed: D3.2 (A), R30.1
unnamed: D3.1 (K), Q2.2 (C), VCA_R1.2
unnamed: J6.T1, J6.TS1, J12.1, VR9.2 (WIPER)
unnamed: C12.2, Q1.3 (B), R21.1
unnamed: Q1.2 (C), R25.2
unnamed: Q1.1 (E), R22.1
unnamed: C20.1, Q2.3 (B), R25.1, R27.2
unnamed: Q2.1 (E), R28.1
unnamed: R6.2, U1.16
unnamed: R7.2, U1.10, U1.12
unnamed: R12.2, U1.5, U1.7
unnamed: R14.1, U1.1
unnamed: R17.1, R24.2, U4.1
unnamed: R26.1, R28.2
unnamed: R13.2, TM1.1 (CCW), U1.8
unnamed: C9.1, TM1.2 (WIPER)
unnamed: R2.2, R3.2, R5.2, U1.14 (+)
unnamed: R4.2, U1.13 (-)
unnamed: R10.2, R11.2, U1.3 (+)
unnamed: R9.2, U1.4 (-)
unnamed: C5.1, R15.2, R23.2, U4.3 (+)
unnamed: R16.2, R24.1, U4.2 (-)
unnamed: U4.6 (-), U4.7
unnamed: C6.2, R20.2, VR9.1 (CCW)
OVD_OUT: C9.2, VR8.1 (CCW)
VAOV_OUT: R23.1, VR8.2 (WIPER)
VCA_OUT: C4.1, C8.2, VR8.3 (CW)

Notes on the sheet:
AudioOut
Overdrive
TB VCA

Schematic: TEMPO.kicad_sch

Parts:
VR1: RK09D117000B; Manufacturer_Part_Number RK09D117000B; Mouser Part Number 688-RK09D117000B

Connections:
A+TEMPO: VR1.2 (WIPER); also elsewhere on the board
D+3.3V: VR1.1 (CCW); also elsewhere on the board
GNDD: VR1.3 (CW), VR1.MH1, VR1.MH2; also elsewhere on the board

Notes on the sheet:
ADC Tempo Volume

Schematic: PowerSupply.kicad_sch

Parts:
C7: 2.2uF/25V; CP_Radial_D5.0mm_P2.50mm
PwC1, PwC3: 10uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
PwC2: 1000uF/25V; CP_Radial_D10.0mm_P5.00mm
PwC4, PwC9: 0.1uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
PwC5: 470uF/25V; CP_Radial_D5.0mm_P2.50mm
PwC6: 100uF/25V; CP_Radial_D5.0mm_P2.50mm
PwD1: SBM245L; D_DO-41_SOD81_P5.08mm_Vertical_AnodeUp; Manufacturer_Part_Number SBM245L
PwF1, PwF2: MF-R050; MFR050; Manufacturer_Part_Number MF-R050; Mouser Part Number 652-MFR050
PwIC1: BP5293-50; TO254P570X1700X1780-3P; Manufacturer_Part_Number BP5293-50; Mouser Part Number 755-BP5293-50
PwIC2: L7812; TO-220-3_Horizontal_TabDown
PwJ1: Barrel_Jack_Switch; BarrelJack_Horizontal
PwJ2, PwJ3, PwJ4, PwJ5: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
PwL1: 4.7uh/0.5A; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
PwS1: 4MS1R202M6QES; Manufacturer_Part_Number 4MS1R202M6QES
R18: 30K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R19: 24K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
U5: Opamp_Dual; DIP-8_W7.62mm_LongPads

Connections:
A+5.333V: U5.1, U5.2 (-), U5.5 (+); also elsewhere on the board
A+12V: PwC6.1, PwC9.1, PwD1.2 (A), PwIC2.3 (OUT), R18.2, U5.8 (V+); also elsewhere on the board
A+15V: PwC2.1, PwC4.1, PwD1.1 (K), PwF1.2, PwIC2.1 (IN)
A+15VPre: PwF1.1, PwJ4.1
ADAPTER GND: PwJ1.2, PwJ1.3, PwJ2.2, PwJ3.2
ADAPTER+15V: PwJ2.1, PwJ3.1, PwS1.2
D+5V: PwC5.1, PwL1.2; also elsewhere on the board
D+15V: PwF2.2, PwIC1.1 (VIN)
D+15VPre: PwC1.1, PwF2.1, PwJ5.1
GNDA: C7.2, PwC2.2, PwC4.2, PwC6.2, PwC9.2, PwIC2.2 (GND), PwJ4.2, R19.1, U5.4 (V-); also elsewhere on the board
GNDD: PwC1.2, PwC3.2, PwC5.2, PwIC1.2 (GND), PwJ5.2; also elsewhere on the board
unnamed: PwC3.1, PwIC1.3 (VOUT), PwL1.1
unnamed: PwJ1.1, PwS1.1
unnamed: C7.1, R18.1, R19.2, U5.3 (+)
unnamed: U5.6 (-), U5.7

Notes on the sheet:
12W級ACアダプター15V0.8A LTE10UW-S3-BS01 https://akizukidenshi.com/catalog/g/g107774/
Analog PowerSupply
5.333V
BP5293-50の実験 https://brainvision.digick.jp/wordpress/bp5293-50%E3%81%AE%E5%AE%9F%E9%A8%93/
Digital PowerSupply

Schematic: LevelConvert.kicad_sch

Parts:
DgC3, DgC4: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgIC2, DgIC3: 74VHC541FT; SOP65P640X120-20N; Manufacturer_Part_Number 74VHC541FT; Mouser Part Number N/A
J4, J5: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J10, J11: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical

Connections:
A+GATE: DgIC2.18 (Y1); also elsewhere on the board
A+SLIDE: DgIC2.17 (Y2); also elsewhere on the board
A+SyncOut: DgIC2.15 (Y4); also elsewhere on the board
A+SyncOut_Run/Stop: DgIC2.14 (Y5); also elsewhere on the board
A-ACC: DgIC2.16 (Y3); also elsewhere on the board
D+3.3V: DgC4.1, DgIC3.20 (VCC); also elsewhere on the board
D+3.3V_MIDIRX: DgIC3.18 (Y1); also elsewhere on the board
D+3.3V_MIDITX: DgIC2.7 (A6); also elsewhere on the board
D+5V: DgC3.1, DgIC2.20 (VCC); also elsewhere on the board
D+5V_MIDIRx: DgIC3.2 (A1); also elsewhere on the board
D+5V_MIDITX: DgIC2.13 (Y6); also elsewhere on the board
D+5V_SyncIn: DgIC3.3 (A2); also elsewhere on the board
D+5V_SyncIn_Run/Stop: DgIC3.4 (A3); also elsewhere on the board
D+GATE: DgIC2.2 (A1); also elsewhere on the board
D+SLIDE: DgIC2.3 (A2); also elsewhere on the board
D+SyncIn: DgIC3.17 (Y2); also elsewhere on the board
D+SyncIn_Run/Stop: DgIC3.16 (Y3); also elsewhere on the board
D+SyncOut: DgIC2.5 (A4); also elsewhere on the board
D+SyncOut_Run/Stop: DgIC2.6 (A5); also elsewhere on the board
D-ACC: DgIC2.4 (A3); also elsewhere on the board
GNDD: DgC3.2, DgC4.2, DgIC2.1 (~G1), DgIC2.10 (GND), DgIC2.19 (~G2), DgIC3.1 (~G1), DgIC3.10 (GND), DgIC3.19 (~G2); also elsewhere on the board
unnamed: DgIC2.8 (A7), J4.1
unnamed: DgIC2.9 (A8), J4.2
unnamed: DgIC2.12 (Y7), J5.1
unnamed: DgIC2.11 (Y8), J5.2
unnamed: DgIC3.5 (A4), J10.1
unnamed: DgIC3.6 (A5), J10.2
unnamed: DgIC3.7 (A6), J10.3
unnamed: DgIC3.8 (A7), J10.4
unnamed: DgIC3.9 (A8), J10.5
unnamed: DgIC3.15 (Y4), J11.1
unnamed: DgIC3.14 (Y5), J11.2
unnamed: DgIC3.13 (Y6), J11.3
unnamed: DgIC3.12 (Y7), J11.4
unnamed: DgIC3.11 (Y8), J11.5

Notes on the sheet:
3.3V=>5V OutputBuffer
5V=>3.3V InputBuffer

Schematic: VCO.kicad_sch

Parts:
C10, C33: 0.01uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C11: 1uF/50V; CP_Radial_D4.0mm_P2.00mm
C34: 0.001uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
D25: D; D_A-405_P2.54mm_Vertical_AnodeUp
J13: Conn_01x01_Pin; PinHeader_1x01_P2.54mm_Vertical
Q8, Q27: PNP; TO-92_HandSolder
Q24, Q25: NPN; TO-92_HandSolder
Q26: HN1C01FU-GR,LF; HN1C01FUGRLF_DIP8; Manufacturer_Part_Number HN4A06J(TE85L,F); Mouser Part Number 757-HN4A06JTE85LF
Q28: NJFET; TO-92_HandSolder
R34, R36, R101, R105: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R35, R102, R118: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R45: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R100: 1K(TEMPCO); R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R103: 220K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R104: 2.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R106: 27K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
SW1: 2MS1T1B4VS2QES; Manufacturer_Part_Number 2MS1T1B4VS2QES; Mouser Part Number N/A
TM4: 50K; 3296W1502A; Manufacturer_Part_Number 3296W-1-502A; Mouser Part Number 652-3296W-1-502A
TM5: 5K; 3296W1502A; Manufacturer_Part_Number 3296W-1-502A; Mouser Part Number 652-3296W-1-502A
U2: Opamp_Dual; DIP-8_W7.62mm_Socket_LongPads
VR2: 50K(B); PTV1113420AA103; Manufacturer_Part_Number PTV111-3420A-A103; Mouser Part Number 652-PTV1113420AA103

Connections:
A+5.333V: Q26.2 (B1), R36.2, R100.2, R101.1, TM4.1 (CCW), U2.3 (+), U2.5 (+), VR2.3 (CW); also elsewhere on the board
A+12V: Q27.1 (E), Q28.1 (D), R45.1, R103.1, TM4.3 (CW), U2.8 (V+); also elsewhere on the board
A+VCO_SAW: C10.2, Q28.3 (S), R35.2, R105.1, SW1.3
A+VCO_SQU: Q8.2 (C), R36.1, SW1.1
A+VCO_WAVE: J13.1, SW1.2 (2_Comm); also elsewhere on the board
GNDA: C11.2, C33.1, R105.2, SW1.MH1, SW1.MH2, U2.4 (V-), VR2.1 (CCW), VR2.MH1, VR2.MH2; also elsewhere on the board
unnamed: C10.1, R34.2
unnamed: C34.2, R104.2, U2.1
unnamed: D25.2 (A), Q27.2 (C)
unnamed: D25.1 (K), Q24.2 (C), Q24.3 (B), Q25.3 (B)
unnamed: Q8.3 (B), R34.1, R35.1
unnamed: C11.1, Q8.1 (E), R45.2
unnamed: Q24.1 (E), R101.2
unnamed: Q25.2 (C), Q27.3 (B)
unnamed: C33.2, Q25.1 (E), Q26.3 (C2), Q28.2 (G)
unnamed: Q26.5 (B2), R100.1, R106.1, R118.2
unnamed: C34.1, Q26.6 (C1), R102.1, R103.2, U2.2 (-)
unnamed: Q26.1 (E1), Q26.4 (E2), R104.1
unnamed: R102.2, TM4.2 (WIPER)
unnamed: R106.2, TM5.1 (CCW), TM5.2 (WIPER)
unnamed: U2.6 (-), U2.7
unnamed: R118.1, VR2.2 (WIPER)

Notes on the sheet:
最終的にはこれに統一 HN1C01FU_DIP
toVCF
TUNE
WIDTH
TUNING

Schematic: MIDIRx.kicad_sch

Parts:
DgC1: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgD1: 1N4148W; D_SOD-123
DgIC4: TLP2304_TPR,E; SOIC127P700X230-6N; Manufacturer_Part_Number TLP2304(TPR,E; Mouser Part Number 757-TLP2304TPRE
DgJ1: KDJ03-5 MIDIOUT; KDJ035; Manufacturer_Part_Number KDJ03-5
DgJ8: KDJ03-5 MIDIIN; KDJ035; Manufacturer_Part_Number KDJ03-5
DgR3, DgR4, DgR8, DgR9: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
IC3: 74AHC1G04W5-7; SOT95P285X140-5N; Manufacturer_Part_Number 74AHC1G04W5-7; Mouser Part Number 621-74AHC1G04W5-7
Q4: 2SC3325-Y; 2SC3325YLF; Manufacturer_Part_Number 2SC3325-Y

Connections:
D+5V: DgC1.1, DgIC4.6 (VCC), DgR4.1, DgR8.1, IC3.5 (VCC); also elsewhere on the board
D+5V_MIDIRx: DgIC4.5 (VO_(OUTPUT)), DgR4.2; also elsewhere on the board
D+5V_MIDITX: IC3.2 (A); also elsewhere on the board
GNDD: DgC1.2, DgIC4.4 (GND), DgJ1.2, DgJ1.MH1, DgJ1.MH2, DgJ8.MH1, DgJ8.MH2, IC3.3 (GND), Q4.2 (E); also elsewhere on the board
unnamed: DgD1.2 (A), DgIC4.3 (CATHODE), DgJ8.5
unnamed: DgD1.1 (K), DgIC4.1 (ANODE), DgR3.2
unnamed: DgJ1.4, DgR8.2
unnamed: DgJ1.5, DgR9.2
unnamed: DgJ8.4, DgR3.1
unnamed: IC3.4 (Y), Q4.1 (B)
unnamed: DgR9.1, Q4.3 (C)

Notes on the sheet:
MIDI送受信回路で使うオプトアイソレータはどれが良い？ https://b.meso.tokyo/post/722104583178092544/opt-isolator-selection-guide-for-midi ⇒TLP2361,TLP2304
MIDI Interface Tx
MIDI Interface Rx
Vcc=5Vで動作確認済(Vcc=3.3Vだと動作できない事も確認した)

Schematic: Jack.kicad_sch

Parts:
AnPw1: AnPw; PinSocket_1x03_P2.54mm_Vertical
DgJ9: MJ-8435 SYNC IN; MJ-8435; Manufacturer_Part_Number MJ-8435
DgJ11: MJ-8435 CV OUT; MJ-8435; Manufacturer_Part_Number MJ-8435
DgJ12: MJ-8435 GATE OUT; MJ-8435; Manufacturer_Part_Number MJ-8435
DgJ13: MJ-8435 SYNC OUT; MJ-8435; Manufacturer_Part_Number MJ-8435
DgJ16: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
DgPw1: DgPw; PinSocket_1x03_P2.54mm_Vertical
J14: Conn_01x05; JST_XH_S5B-XH-A-1_1x05_P2.50mm_Horizontal

Connections:
A+5.333V: AnPw1.2; also elsewhere on the board
A+12V: AnPw1.1; also elsewhere on the board
A+CV: DgJ16.1; also elsewhere on the board
A+GATE: DgJ12.2 (2_1), DgJ12.3 (2_2), DgJ16.5; also elsewhere on the board
A+SLIDE: DgJ16.3; also elsewhere on the board
A+SyncOut: DgJ13.2 (2_1); also elsewhere on the board
A+SyncOut_Run/Stop: DgJ13.3 (2_2); also elsewhere on the board
A-ACC: DgJ16.4; also elsewhere on the board
D+3.3V: DgPw1.2, J14.1; also elsewhere on the board
D+5V: DgPw1.1; also elsewhere on the board
D+5V_SyncIn: DgJ9.2 (2_1); also elsewhere on the board
D+5V_SyncIn_Run/Stop: DgJ9.3 (2_2); also elsewhere on the board
D_I2C_SCL: J14.3; also elsewhere on the board
D_I2C_SDA: J14.2; also elsewhere on the board
GNDA: AnPw1.3; also elsewhere on the board
GNDD: DgJ9.1, DgJ11.1, DgJ12.1, DgJ13.1, DgPw1.3, J14.5; also elsewhere on the board

Notes on the sheet:
SYNC OUT
toPanelBorad
CV OUT
SYNC IN
Interface
GATE OUT
Power

Schematic: Interface.kicad_sch

Parts:
C35: 0.22uF; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C54: 0.047uF; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C55: 47uF/16V; CP_Radial_D4.0mm_P2.00mm
C62: 1uF/50V; CP_Radial_D5.0mm_P2.00mm
C72: 10uF/16V; CP_Radial_D4.0mm_P2.00mm
D26, D28, D29, D31, D32, D37: D; D_A-405_P2.54mm_Vertical_AnodeUp
IC2: NJM2125F-TE1; SOT95P280X130-5N; Manufacturer_Part_Number NJM2125F-TE1; Mouser Part Number 513-NJM2125F-TE1
IC12: 4066; DIP-14_W7.62mm_LongPads
J7: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J8: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
Q29, Q30, Q35, Q37, Q40, Q41: NPN; TO-92_HandSolder
Q36, Q38: PNP; TO-92_HandSolder
Q39: NJFET; TO-92_HandSolder
R59, R92, R93, R139, R140, R141: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R91: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R107: 2.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R117, R146, R151: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R138: 68K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R142, R143, R144, R145, R148, R149: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R147, R150: 22; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R152: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
VR6: 1M(A); PTV1113420AA103; Manufacturer_Part_Number PTV111-3420A-A103; Mouser Part Number 652-PTV1113420AA103
VR7: 50K(B); PTV1113420AA103; Manufacturer_Part_Number PTV111-3420A-A103; Mouser Part Number 652-PTV1113420AA103

Connections:
A+5.333V: D31.1 (K), R117.1; also elsewhere on the board
A+12V: C72.1, IC2.5 (V+), IC12.14 (VDD), Q40.2 (C), Q41.2 (C), R92.2, R93.2, R139.1, R142.2, R147.1, R149.1, R150.1; also elsewhere on the board
A+CV: IC2.1 (+INPUT), IC12.2; also elsewhere on the board
A+ENV.MOD: IC12.9, J8.1, Q39.1 (D), Q40.1 (E); also elsewhere on the board
A+ENV_Trig: C54.2, Q37.2 (C), R143.2
A+VCA-Reso_ACC: J7.1, J8.2, VR7.2 (WIPER); also elsewhere on the board
A+VCA_Env: D37.2 (A), J7.3, Q38.2 (C), R151.1; also elsewhere on the board
A+VCA_Trig: J7.2, Q36.2 (C), R145.2; also elsewhere on the board
D+GATE: R146.1; also elsewhere on the board
D+SLIDE: R59.1; also elsewhere on the board
D-ACC: R141.1; also elsewhere on the board
GNDA: C35.2, C55.2, C62.2, D26.1 (K), D32.2 (A), IC2.2 (GND), IC12.7 (VSS), Q29.1 (E), Q30.1 (E), Q35.1 (E), Q37.1 (E), Q39.2 (G), Q39.3 (S), R140.2, R144.1, R145.1, R151.2, VR6.MH1, VR6.MH2, VR7.1 (CCW), VR7.MH1, VR7.MH2; also elsewhere on the board
unnamed: C35.1, IC12.1, IC12.4
unnamed: C54.1, R148.2
unnamed: D26.2 (A), D29.1 (K), R117.2
unnamed: D28.2 (A), IC12.11, VR6.2 (WIPER), VR6.3 (CW)
unnamed: D28.1 (K), D29.2 (A)
unnamed: D37.1 (K), R152.2
unnamed: Q29.3 (B), R59.2
unnamed: IC12.5, Q29.2 (C), R91.1, R92.1
unnamed: Q30.3 (B), R91.2
unnamed: IC12.13, Q30.2 (C), R93.1
unnamed: Q35.3 (B), R140.1, R141.2
unnamed: IC12.6, IC12.12, Q35.2 (C), R139.2
unnamed: C72.2, Q36.3 (B), R142.1, R143.1
unnamed: Q36.1 (E), R147.2
unnamed: Q37.3 (B), R144.2, R146.2
unnamed: Q38.3 (B), R148.1, R149.2
unnamed: C55.1, Q38.1 (E), R150.2
unnamed: Q40.3 (B), Q41.1 (E)
unnamed: C62.1, Q41.3 (B), R138.2, R152.1
unnamed 189: IC2.3 (-INPUT), R107.1; also elsewhere on the board
unnamed: IC12.10, R138.1, VR6.1 (CCW)
unnamed: IC12.8, VR7.3 (CW)

Notes on the sheet:
Accent
Gate
Envelope
toVCF
Slide
EnvDecay
toVCA

Schematic: CV.kicad_sch

Parts:
DgC2: 0.047uF; C_Rect_L7.0mm_W2.5mm_P5.00mm
DgC6: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgIC5: LM358; SOIC-8_3.9x4.9mm_P1.27mm
DgR5: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
DgR6: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
DgR7: 5.1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical

Connections:
A+CV: DgIC5.7, DgR7.2; also elsewhere on the board
D+5V: DgC6.1, DgIC5.8 (V+); also elsewhere on the board
D+CV_PWM: DgR5.1; also elsewhere on the board
GNDD: DgC2.2, DgC6.2, DgIC5.4 (V-), DgR6.2; also elsewhere on the board
unnamed: DgC2.1, DgIC5.3 (+), DgR5.2
unnamed: DgIC5.1, DgIC5.2 (-), DgIC5.5 (+)
unnamed: DgIC5.6 (-), DgR6.1, DgR7.1

Notes on the sheet:
CV PMW to DAC Convert

Schematic: FRAM.kicad_sch

Parts:
DgC5: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
DgIC1: FM24CL16B-GTR; SOIC127P602X173-8N; Manufacturer_Part_Number FM24CL16B-GTR; Mouser Part Number 877-FM24CL16B-GTR

Connections:
D+3.3V: DgC5.1, DgIC1.8 (VDD); also elsewhere on the board
D_I2C_SCL: DgIC1.6 (SCL); also elsewhere on the board
D_I2C_SDA: DgIC1.5 (SDA); also elsewhere on the board
GNDD: DgC5.2, DgIC1.4 (VSS), DgIC1.7 (WP); also elsewhere on the board

Notes on the sheet:
F-RAM 16KByte

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
Board: 2 copper layers, 263 parts (9 on the bottom side), 209 nets, no tracks yet.

Other parts of the board:
IC4: NJM2125F-TE1; SOT95P280X130-5N
U3: Opamp_Dual; DIP-8_W7.62mm_LongPads

Their connections:
A+5.333V: IC4.3 (-INPUT), IC4.4 (OUTPUT), U3.5 (+); also elsewhere on the board
A+12V: IC4.5 (V+), U3.8 (V+); also elsewhere on the board
A+CV: U3.3 (+); also elsewhere on the board
GNDA: IC4.2 (GND), U3.4 (V-); also elsewhere on the board
unnamed 189: U3.2 (-); also elsewhere on the board
unnamed: U3.6 (-), U3.7

## KiCad design TBSEQ_Board_V2/SyncBoard/SyncBoard.kicad_pcb

Schematic: SyncBoard.kicad_sch

Parts:
C1, C2: 0.1uf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
IC1, IC2: TC74VHC541F; SOIC127P780X190-20N; Manufacturer_Part_Number TC74VHC541F; Mouser Part Number 757-TC74VHC541F
J1, J2: AudioJack3_SwitchTR; Jack_3.5mm_CUI_SJ1-3515N_Horizontal
J3, J4, J5, J6: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
S1: SS12D00G3; Manufacturer_Part_Number SS12D00G3
U1: Raspberry Pi Pico DIP-40_W17.76mm

Connections:
A+SyncIn: IC2.2 (A1), J2.T, J2.TN
A+SyncIn_Run/Stop: IC2.3 (A2), J2.R, J2.RN
A+SyncOut: IC1.18 (Y1), J1.T, J1.TN
A+SyncOut_Run/Stop: IC1.17 (Y2), J1.R, J1.RN
D+3.3V: C2.2, IC2.20 (VCC), S1.1 (NC), U1.36 (3V3(OUT))
D+5V: C1.2, IC1.20 (VCC), U1.40 (VBUS)
D+Plugin_SyncIn: S1.2 (COM), U1.20 (GP15)
D+SyncIn: IC2.18 (Y1), U1.21 (GP16)
D+SyncIn_Run/Stop: IC2.17 (Y2), U1.17 (GP13)
D+SyncOut: IC1.2 (A1), U1.22 (GP17)
D+SyncOut_Run/Stop: IC1.3 (A2), U1.19 (GP14)
GNDD: C1.1, C2.1, IC1.1 (~G1), IC1.10 (GND), IC1.19 (~G2), IC2.1 (~G1), IC2.10 (GND), IC2.19 (~G2), J1.S, J2.S, S1.3 (NO), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (GND), U1.38 (GND)
unnamed: IC1.4 (A3), J5.6
unnamed: IC1.5 (A4), J5.5
unnamed: IC1.6 (A5), J5.4
unnamed: IC1.7 (A6), J5.3
unnamed: IC1.8 (A7), J5.2
unnamed: IC1.9 (A8), J5.1
unnamed: IC1.16 (Y3), J6.6
unnamed: IC1.15 (Y4), J6.5
unnamed: IC1.14 (Y5), J6.4
unnamed: IC1.13 (Y6), J6.3
unnamed: IC1.12 (Y7), J6.2
unnamed: IC1.11 (Y8), J6.1
unnamed: IC2.4 (A3), J3.6
unnamed: IC2.5 (A4), J3.5
unnamed: IC2.6 (A5), J3.4
unnamed: IC2.7 (A6), J3.3
unnamed: IC2.8 (A7), J3.2
unnamed: IC2.9 (A8), J3.1
unnamed: IC2.16 (Y3), J4.6
unnamed: IC2.15 (Y4), J4.5
unnamed: IC2.14 (Y5), J4.4
unnamed: IC2.13 (Y6), J4.3
unnamed: IC2.12 (Y7), J4.2
unnamed: IC2.11 (Y8), J4.1

Notes on the sheet:
RasberyPiPico(TopViewMount)
SyncIn
3.3V->5VConvert
SyncSW
SyncOut
5V->3.3VConvert

Board: 2 copper layers, 50.0 x 80.0 mm, 12 parts (0 on the bottom side), 36 nets.
