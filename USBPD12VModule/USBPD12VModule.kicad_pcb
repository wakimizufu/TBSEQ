# Repository wakimizufu/TBSEQ (continued)

## KiCad design TBSEQ_Board_V4/rythemPanelBoard/rythemPanelBoard.kicad_pcb (continued)

Parts:
S1, S2, S3, S4, S5, S6, S7, S8, S9, S10, S11, S12, S13, S14, S15, S16, S17, S18, S19, S20, S21, S22, S23, S24, S25, S26, S27, S28, S29, S30, S31, S32: FSM6JSMATR; Manufacturer_Part_Number FSM6JSMATR; Mouser Part Number N/A

Connections:
COM1/KS0: S1.3 (NO_1), S1.4 (NO_2), S2.3 (NO_1), S2.4 (NO_2), S3.3 (NO_1), S3.4 (NO_2), S4.3 (NO_1), S4.4 (NO_2), S5.3 (NO_1), S5.4 (NO_2), S6.3 (NO_1), S6.4 (NO_2), S7.3 (NO_1), S7.4 (NO_2), S8.3 (NO_1), S8.4 (NO_2), S9.3 (NO_1), S9.4 (NO_2), S10.3 (NO_1), S10.4 (NO_2), S11.3 (NO_1), S11.4 (NO_2), S12.3 (NO_1), S12.4 (NO_2), S13.3 (NO_1), S13.4 (NO_2); also elsewhere on the board
COM2/KS1: S14.3 (NO_1), S14.4 (NO_2), S15.3 (NO_1), S15.4 (NO_2), S16.3 (NO_1), S16.4 (NO_2), S17.3 (NO_1), S17.4 (NO_2), S18.3 (NO_1), S18.4 (NO_2), S19.3 (NO_1), S19.4 (NO_2), S20.3 (NO_1), S20.4 (NO_2), S21.3 (NO_1), S21.4 (NO_2), S22.3 (NO_1), S22.4 (NO_2), S23.3 (NO_1), S23.4 (NO_2), S24.3 (NO_1), S24.4 (NO_2), S25.3 (NO_1), S25.4 (NO_2), S26.3 (NO_1), S26.4 (NO_2); also elsewhere on the board
COM3/KS2: S27.3 (NO_1), S27.4 (NO_2), S28.3 (NO_1), S28.4 (NO_2), S29.3 (NO_1), S29.4 (NO_2), S30.3 (NO_1), S30.4 (NO_2), S31.3 (NO_1), S31.4 (NO_2), S32.3 (NO_1), S32.4 (NO_2); also elsewhere on the board
RowK3: S1.1 (COM_1), S1.2 (COM_2), S14.1 (COM_1), S14.2 (COM_2), S27.1 (COM_1), S27.2 (COM_2); also elsewhere on the board
RowK4: S2.1 (COM_1), S2.2 (COM_2), S15.1 (COM_1), S15.2 (COM_2), S28.1 (COM_1), S28.2 (COM_2); also elsewhere on the board
RowK5: S3.1 (COM_1), S3.2 (COM_2), S16.1 (COM_1), S16.2 (COM_2), S29.1 (COM_1), S29.2 (COM_2); also elsewhere on the board
RowK6: S4.1 (COM_1), S4.2 (COM_2), S17.1 (COM_1), S17.2 (COM_2), S30.1 (COM_1), S30.2 (COM_2); also elsewhere on the board
RowK7: S5.1 (COM_1), S5.2 (COM_2), S18.1 (COM_1), S18.2 (COM_2), S31.1 (COM_1), S31.2 (COM_2); also elsewhere on the board
RowK8: S6.1 (COM_1), S6.2 (COM_2), S19.1 (COM_1), S19.2 (COM_2), S32.1 (COM_1), S32.2 (COM_2); also elsewhere on the board
RowK9: S7.1 (COM_1), S7.2 (COM_2), S20.1 (COM_1), S20.2 (COM_2); also elsewhere on the board
RowK10: S8.1 (COM_1), S8.2 (COM_2), S21.1 (COM_1), S21.2 (COM_2); also elsewhere on the board
RowK11: S9.1 (COM_1), S9.2 (COM_2), S22.1 (COM_1), S22.2 (COM_2); also elsewhere on the board
RowK12: S10.1 (COM_1), S10.2 (COM_2), S23.1 (COM_1), S23.2 (COM_2); also elsewhere on the board
RowK13: S11.1 (COM_1), S11.2 (COM_2), S24.1 (COM_1), S24.2 (COM_2); also elsewhere on the board
RowK14: S12.1 (COM_1), S12.2 (COM_2), S25.1 (COM_1), S25.2 (COM_2); also elsewhere on the board
RowK15: S13.1 (COM_1), S13.2 (COM_2), S26.1 (COM_1), S26.2 (COM_2); also elsewhere on the board

Notes on the sheet:
4:STEP4
13:STEP13
11:STEP11
1:STEP1
19:PATTERN
10:STEP10
27:BANK C
5:STEP5
14:STEP14
2:STEP2
18:TRACK
24:FUNC
16:STEP16
3:STEP3
7:STEP7
31:SCALE C
8:STEP8
6:STEP6
32:SCALE D
21:INST
26:BANK B
17:RUN/STOP
23:SHUFFLE
9:STEP9
25:BANK A
29:SCALE A
12:STEP12
22:LENGTH
20:WRITE
15:STEP15
30:SCALE B
28:BANK D

Parts:
C1: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3: 1N4148W; D_SOD-123
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13: 39k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U7: HT16K33_28SOP-A_; SOIC127P1031X264-28N; Manufacturer_Part_Number HT16K33(28SOP-A)

Connections:
COM0: U7.2 (COM0/AD); also elsewhere on the board
COM1: D1.2 (A), U7.3 (COM1/KS0); also elsewhere on the board
COM1/KS0: D1.1 (K); also elsewhere on the board
COM2/KS1: D2.1 (K); also elsewhere on the board
COM3/KS2: D3.1 (K); also elsewhere on the board
D+3.3V: C1.1, U7.28 (VDD); also elsewhere on the board
D_I2C_SCL: U7.26 (SCL); also elsewhere on the board
D_I2C_SDA: U7.27 (SDA); also elsewhere on the board
GNDD: C1.2, U7.1 (VSS); also elsewhere on the board
unnamed: D2.2 (A), U7.4 (COM2/KS1)
unnamed: D3.2 (A), U7.5 (COM3/KS2)
Row0: U7.25 (ROW0/A2); also elsewhere on the board
Row1: U7.24 (ROW1/A1); also elsewhere on the board
Row2: U7.23 (ROW2/A0); also elsewhere on the board
Row3: R1.1, U7.22 (ROW3/K1); also elsewhere on the board
Row4: R2.1, U7.21 (ROW4/K2); also elsewhere on the board
Row5: R3.1, U7.20 (ROW5/K3); also elsewhere on the board
Row6: R4.1, U7.19 (ROW6/K4); also elsewhere on the board
Row7: R5.1, U7.18 (ROW7/K5); also elsewhere on the board
Row8: R6.1, U7.17 (ROW8/K6); also elsewhere on the board
Row9: R7.1, U7.16 (ROW9/K7); also elsewhere on the board
Row10: R8.1, U7.15 (ROW10/K8); also elsewhere on the board
Row11: R9.1, U7.14 (ROW11/K9); also elsewhere on the board
Row12: R10.1, U7.13 (ROW12/K10); also elsewhere on the board
Row13: R11.1, U7.12 (ROW13/K11); also elsewhere on the board
Row14: R12.1, U7.11 (ROW14/K12); also elsewhere on the board
Row15: R13.1, U7.10 (ROW15/K13/INT); also elsewhere on the board
RowK3: R1.2; also elsewhere on the board
RowK4: R2.2; also elsewhere on the board
RowK5: R3.2; also elsewhere on the board
RowK6: R4.2; also elsewhere on the board
RowK7: R5.2; also elsewhere on the board
RowK8: R6.2; also elsewhere on the board
RowK9: R7.2; also elsewhere on the board
RowK10: R8.2; also elsewhere on the board
RowK11: R9.2; also elsewhere on the board
RowK12: R10.2; also elsewhere on the board
RowK13: R11.2; also elsewhere on the board
RowK14: R12.2; also elsewhere on the board
RowK15: R13.2; also elsewhere on the board

Parts:
J1: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical
J4: Conn_01x03; PinSocket_1x03_P2.54mm_Vertical

Connections:
A+TEMPO: J4.2; also elsewhere on the board
D+3.3V: J1.1; also elsewhere on the board
D_I2C_SCL: J1.3; also elsewhere on the board
D_I2C_SDA: J1.2; also elsewhere on the board
GNDD: J1.5; also elsewhere on the board
TEMPO_CCW: J4.1; also elsewhere on the board
TEMPO_CW: J4.3; also elsewhere on the board

Notes on the sheet:
CCW
WIPER
ADC Tempo Volume
fromMainBorad

Parts:
D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder

Connections:
COM0: D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K); also elsewhere on the board
COM1: D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K); also elsewhere on the board
Row0: D4.2 (A), D20.2 (A); also elsewhere on the board
Row1: D5.2 (A), D21.2 (A); also elsewhere on the board
Row2: D6.2 (A), D22.2 (A); also elsewhere on the board
Row3: D7.2 (A), D23.2 (A); also elsewhere on the board
Row4: D8.2 (A), D24.2 (A); also elsewhere on the board
Row5: D9.2 (A), D25.2 (A); also elsewhere on the board
Row6: D10.2 (A), D26.2 (A); also elsewhere on the board
Row7: D11.2 (A), D27.2 (A); also elsewhere on the board
Row8: D12.2 (A), D28.2 (A); also elsewhere on the board
Row9: D13.2 (A), D29.2 (A); also elsewhere on the board
Row10: D14.2 (A), D30.2 (A); also elsewhere on the board
Row11: D15.2 (A), D31.2 (A); also elsewhere on the board
Row12: D16.2 (A); also elsewhere on the board
Row13: D17.2 (A); also elsewhere on the board
Row14: D18.2 (A); also elsewhere on the board
Row15: D19.2 (A); also elsewhere on the board

Notes on the sheet:
22:BANK B
16:STEP16
9:STEP9
1:STEP1
25:SCALE A
4:STEP4
20:WRITE
14:STEP14
5:STEP5
17:RUN/STOP
13:STEP13
2:STEP2
3:STEP3
23:BANK C
26:SCALE B
10:STEP10
21:BANK A
18:TRACK
28:SCALE D
27:SCALE C
19:PATTERN
7:STEP7
11:STEP11
24:BANK D
15:STEP15
6:STEP6
12:STEP12
8:STEP8

Board: 2 copper layers, 180.0 x 55.4 mm, 81 parts (18 on the bottom side), 43 nets.

## KiCad design TBSEQ_Board_V4/mainBorad/mainBorad_R1.kicad_pcb

Parts:
C11: 47uF/16V; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C12, C19, C22, C23, C24, C25, C26: 1uF/50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C13, C14: 10uF/16V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C15, C16, C18: 0.033uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C17: 0.018uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C20, C21: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D9: 1N4148W; D_SOD-123
J10: VCA Input; PinHeader_1x02_P2.54mm_Vertical
Q17, Q18, Q29: HN1C01FU-GR,LF; HN1C01FUGRLF; Manufacturer_Part_Number HN4A06J(TE85L,F); Mouser Part Number 757-HN4A06JTE85LF
Q19, Q20, Q21, Q22, Q23, Q24, Q26, Q27, Q30, Q31: 2SC3325-Y; 2SC3325YLF; Manufacturer_Part_Number 2SC3325-Y
Q25, Q28: 2SA1162-GR_F_; 1SS294LFT; Manufacturer_Part_Number 2SA1162-GR(F)
R36, R53: 220K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R37: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R38, R39, R41, R42, R50, R51, R55: 2.2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R40, R43, R44, R45, R47, R48, R57, R59, R60, R64, R65: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R46, R49, R52, R54, R61, R62: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R56, R58: 22K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R63: 47K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TM3: 3362P-1-504LF FREQ; 3362P_1; Manufacturer_Part_Number 3362P-1-103LF; Mouser Part Number 652-3362P-1-103LF
VR4: 50K(B)2連RESONANCE; PTV1124420AA504; Manufacturer_Part_Number PTV112-4420A-A504; Mouser Part Number 652-PTV1124420AA504
VR5: 50K(A)CUTOFF.FREQ; PTV1113420AA103; Manufacturer_Part_Number PTV111-3420A-A103; Mouser Part Number 652-PTV1113420AA103
VR6: 50K(A)ENV.MOD; PTV1113420AA103; Manufacturer_Part_Number PTV111-3420A-A103; Mouser Part Number 652-PTV1113420AA103

Connections:
A+5.333V: R38.2, R43.2, R57.1, R62.1; also elsewhere on the board
A+12V: Q30.3 (C), R37.1, VR5.3 (CW); also elsewhere on the board
A+ENV.MOD: VR6.3 (CW); also elsewhere on the board
A+VCA-Reso_ACC: D9.2 (A); also elsewhere on the board
A+VCA_Resonance: C22.2, J10.2, VR4.A2 (WIPER_1); also elsewhere on the board
A+VCA_Signal: C24.2, J10.1, VR4.A3 (CW_1); also elsewhere on the board
A+VCO_WAVE: R36.2; also elsewhere on the board
GNDA: C11.2, C13.2, C14.2, C23.2, C25.2, C26.2, Q25.3 (C), R44.2, R48.2, R50.2, R59.2, R60.2, VR4.A1 (CCW_1), VR4.MH1, VR4.MH2, VR5.MH1, VR5.MH2, VR6.MH1, VR6.MH2; also elsewhere on the board
unnamed: C12.1, R36.1
unnamed: C13.1, R38.1, R39.2, R41.2
unnamed: C19.1, R45.1
unnamed: C22.1, R55.2
unnamed: C23.1, R46.2, R47.1, R54.2, R57.2
unnamed: C25.1, R61.1, R62.2
unnamed: D9.1 (K), R63.2
unnamed: C12.2, Q17.2 (B1), R39.1
unnamed: Q17.5 (B2), R41.1, R45.2
unnamed: C17.1, Q17.6 (C1), Q21.2 (E)
unnamed: C17.2, Q17.3 (C2), Q24.2 (E)
unnamed: Q17.1 (E1), Q17.4 (E2), R42.2
unnamed: C14.1, Q18.2 (B1), Q18.5 (B2), R40.2
unnamed: C11.1, Q18.3 (C2), Q18.6 (C1), Q31.3 (C), R37.2, R40.1, R56.1, R58.1
unnamed: C18.1, C21.1, Q18.1 (E1), Q19.1 (B), Q19.3 (C)
unnamed: C18.2, C20.1, Q18.4 (E2), Q22.1 (B), Q22.3 (C)
unnamed: C15.1, Q19.2 (E), Q20.1 (B), Q20.3 (C)
unnamed: C16.1, Q20.2 (E), Q21.1 (B), Q21.3 (C)
unnamed: C15.2, Q22.2 (E), Q23.1 (B), Q23.3 (C)
unnamed: C16.2, Q23.2 (E), Q24.1 (B), Q24.3 (C)
unnamed: Q25.1 (B), R43.1, R44.1
unnamed: Q25.2 (E), Q26.2 (E), Q28.3 (C), R51.2, R64.2, R65.2
unnamed: Q26.1 (B), Q28.2 (E), R49.2
unnamed: Q26.3 (C), R42.1
unnamed: Q27.1 (B), R47.2, R48.1
unnamed: Q27.3 (C), Q29.1 (E1), Q29.4 (E2)
unnamed: Q27.2 (E), R50.1
unnamed: Q28.1 (B), R51.1, R52.2, R53.2
unnamed: C20.2, Q29.2 (B1), R46.1
unnamed: C21.2, Q29.5 (B2), R54.1
unnamed: Q29.6 (C1), R56.2
unnamed: Q29.3 (C2), Q31.1 (B), R58.2
unnamed: Q30.1 (B), R55.1, R61.2
unnamed: C19.2, Q30.2 (E), R59.1
unnamed: C24.1, Q31.2 (E), R60.1
unnamed: R49.1, TM3.1 (CCW), TM3.2 (WIPER)
unnamed: TM3.3 (CW), VR5.2 (WIPER)
unnamed: R63.1, VR4.B1 (CCW_2)
unnamed: C26.1, VR4.B3 (CW_2)
unnamed: R52.1, VR4.B2 (WIPER_2)
unnamed: R64.1, VR5.1 (CCW)
unnamed: R65.1, VR6.1 (CCW)
unnamed: R53.1, VR6.2 (WIPER)

Notes on the sheet:
A+VCA_Signal
最終的にはこれに統一 HN1C01FU_DIP
RESONANCE
toVCA
CUTOFF.FREQ
FREQ
ENV.MOD

Parts:
DgJ2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
DgR1, DgR2: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
DgU1: Raspberry Pi Pico DIP-40; Raspberry Pi Pico DIP-40_W17.76mm
DgU2: IRLML6402; SOT-23W_Handsoldering
S1: TS-06104; TS06104; Manufacturer_Part_Number TS-06104

Connections:
A+TEMPO: DgU1.31 (GP26); also elsewhere on the board
D+3.3V: DgR1.1, DgR2.1, DgU1.36 (3V3(OUT)); also elsewhere on the board
D+3.3V_MIDIRX: DgJ2.2, DgU1.2 (GP1); also elsewhere on the board
D+3.3V_MIDITX: DgJ2.1, DgU1.1 (GP0); also elsewhere on the board
D+5V: DgU2.3 (D); also elsewhere on the board
D+CV_PWM: DgU1.27 (GP21); also elsewhere on the board
D+GATE: DgU1.24 (GP18); also elsewhere on the board
D+SLIDE: DgU1.26 (GP20); also elsewhere on the board
D+SyncIn: DgU1.21 (GP16); also elsewhere on the board
D+SyncIn_Run/Stop: DgU1.17 (GP13); also elsewhere on the board
D+SyncOut: DgU1.22 (GP17); also elsewhere on the board
D+SyncOut_Run/Stop: DgU1.19 (GP14); also elsewhere on the board
D+VBUS: DgU1.40 (VBUS), DgU2.1 (G)
D+VSYS: DgU1.39 (VSYS), DgU2.2 (S)
D-ACC: DgU1.25 (GP19); also elsewhere on the board
D_I2C_SCL: DgR2.2, DgU1.7 (GP5); also elsewhere on the board
D_I2C_SDA: DgR1.2, DgU1.6 (GP4); also elsewhere on the board
GNDD: DgU1.3 (GND), DgU1.8 (GND), DgU1.13 (GND), DgU1.18 (GND), DgU1.23 (GND), DgU1.28 (GND), DgU1.33 (GND), DgU1.38 (GND), S1.C1 (NO_1), S1.D1 (NO_2); also elsewhere on the board
unnamed: DgJ2.3, DgU1.4 (GP2)
unnamed: DgJ2.4, DgU1.5 (GP3)
unnamed: DgU1.30 (RUN), S1.A1 (COM_1), S1.B1 (COM_2)

Notes on the sheet:
ラズパイPico：電池で動作、電池の電圧をOLEDに表示 https://qiita.com/totuto/items/38349e66865d518c45d8
USBコネクタ接続時 電流逆流防止
Raspberry Pi Pico Reset Button
Raspberry Pi Pico

Parts:
C33, C37: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C34: 0.22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C35: 47Pf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C36: 0.015uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D13, D14, D15: 1N4148W; D_SOD-123
Q34, Q35: 2SK208; SSM3J375FLXHF; Manufacturer_Part_Number 2SK208
Q36: 2SA1162-GR_F_; 1SS294LFT; Manufacturer_Part_Number 2SA1162-GR(F)
R82, R88: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R83, R86: 2.2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R84: 4.7K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R85: 2.8K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R87: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
VR8: 20K(B)OVERDRIVE; PTV1113420AA103; Manufacturer_Part_Number PTV111-3420A-A103; Mouser Part Number 652-PTV1113420AA103

Connections:
A+5.333V: R82.2; also elsewhere on the board
A+12V: Q35.2 (D), Q36.2 (E), R83.1; also elsewhere on the board
DC_OUT: C37.2, R88.1; also elsewhere on the board
GNDA: C34.2, C36.2, R84.2, R86.2, R88.2, VR8.MH1, VR8.MH2; also elsewhere on the board
unnamed: C34.1, R85.2
unnamed: C36.1, C37.1, R87.2
unnamed: C35.2, D13.2 (A), D14.1 (K), Q35.3 (G), R85.1, VR8.1 (CCW)
unnamed: C35.1, D13.1 (K), D15.2 (A), Q36.3 (C), R86.1, R87.1, VR8.2 (WIPER), VR8.3 (CW)
unnamed: D14.2 (A), D15.1 (K)
unnamed: Q34.2 (D), Q36.1 (B), R83.2
unnamed: C33.1, Q34.3 (G), R82.1
unnamed: Q34.1 (S), Q35.1 (S), R84.1
VCA_OUT: C33.2; also elsewhere on the board

Parts:
C27: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C28: 0.033uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C29, C30: 0.01uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C31: 1uF/50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C32: 10uF/25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D10, D11, D12: 1N4148W; D_SOD-123
Q32: 2SC3325-Y; 2SC3325YLF; Manufacturer_Part_Number 2SC3325-Y
Q33: 2SA1162-GR_F_; 1SS294LFT; Manufacturer_Part_Number 2SA1162-GR(F)
R66, R71: 22K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R67, R69: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R68: 47K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R70, R73, R77, R78: 2.2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R72: 1.5M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R74, R75: 220K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R76: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R79: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R80: 33K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R81: 5.1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U2: LM13700; SO-16_3.9x9.9mm_P1.27mm

Connections:
A+5.333V: R73.1, R80.1; also elsewhere on the board
A+12V: R72.1, U2.11 (V+); also elsewhere on the board
A+VCA-Reso_ACC: R68.2; also elsewhere on the board
A+VCA_Env: D10.2 (A); also elsewhere on the board
A+VCA_Resonance: C30.1; also elsewhere on the board
A+VCA_Signal: C29.1; also elsewhere on the board
A+VCA_Trig: D11.2 (A); also elsewhere on the board
GNDA: C27.1, C28.1, C31.2, C32.2, R67.2, R81.1, U2.6 (V-); also elsewhere on the board
unnamed: C28.2, R68.1, R71.2
unnamed: C29.2, R75.1
unnamed: C30.2, R76.1
unnamed: C32.1, R73.2, R77.1, R78.1
unnamed: D10.1 (K), R66.2
unnamed: D11.1 (K), R70.2
unnamed: D12.2 (A), R71.1
unnamed: D12.1 (K), Q33.3 (C), R79.1
unnamed: C27.2, Q32.1 (B), R66.1
unnamed: Q32.3 (C), R69.2
unnamed: Q32.2 (E), R67.1
unnamed: C31.1, Q33.1 (B), R69.1, R72.2
unnamed: Q33.2 (E), R74.1
unnamed: R70.1, R74.2
unnamed: R79.2, U2.16
unnamed: R80.2, U2.10, U2.12
unnamed: R75.2, R76.2, R78.2, U2.14 (+)
unnamed: R77.2, U2.13 (-)
VCA_OUT: R81.2, U2.9; also elsewhere on the board

Notes on the sheet:
TB VCA
